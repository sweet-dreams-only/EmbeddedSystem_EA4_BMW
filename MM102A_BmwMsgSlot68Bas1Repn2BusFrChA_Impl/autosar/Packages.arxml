<?xml version="1.0" encoding="utf-8"?>
<!--This file was saved with a tool from Vctr Informatik GmbH-->
<AUTOSAR xsi:schemaLocation="http://autosar.org/schema/r4.0 AUTOSAR_4-0-3.xsd" xmlns="http://autosar.org/schema/r4.0" xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance">
  <AR-PACKAGES>
    <AR-PACKAGE UUID="EA049788-5E14-4B39-A577-C4D3BEB7F403">
      <SHORT-NAME>AUTOSAR_Platform</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="1C6D6F63-1CEF-4917-BCE7-FBC8366E4628">
          <SHORT-NAME>BaseTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="88C271C1-8BF6-4CB1-A531-6CCF3317DC04">
          <SHORT-NAME>CompuMethods</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="070BF8B7-AEBD-4A24-8491-6A8C6D62324A">
          <SHORT-NAME>DataConstrs</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="C1E212B3-9E2B-4B10-AC48-8FA2F96DA634">
          <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="6B77E57D-2C9F-443A-ACAD-3AC681B04F41">
      <SHORT-NAME>Blueprints</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="5973249F-9076-474C-A3A4-C466F4376F37">
          <SHORT-NAME>BlueprintMappingSets</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="AFBBDEE0-0827-49D0-B354-F1E62CAADACF">
          <SHORT-NAME>PortPrototypeBlueprints</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="15C9B95F-862C-4786-B6B3-368C99D9DDF0">
      <SHORT-NAME>BMW</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="6E416760-F7FE-4AEF-8314-ED8ABAE4D0D3">
          <SHORT-NAME>Boardnet</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="E4FA4E38-730E-4CDD-A76A-726364D4CA64">
              <SHORT-NAME>CodingDatatypes</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="907E0AA5-0773-43A2-9AF8-9CA3B4C0676C">
                  <SHORT-NAME>CompuMethodsForBoardnet</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="555C167C-DEF4-4A94-8EA5-194E88F23ABA">
                  <SHORT-NAME>DataConstraints</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="2FCBBFE8-306C-4145-B041-D9C2BBC94310">
                  <SHORT-NAME>SwBaseTypes</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="2AA0759C-AF7E-4F01-B284-A1AED9FEDCEF">
          <SHORT-NAME>Platform</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="8A8E44EC-8B12-4891-BA61-22B91A3677F3">
              <SHORT-NAME>Auth</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="CE669CFB-0634-4B79-8C47-795B3BD5AD92">
                  <SHORT-NAME>Dcm</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="13102707-B27E-464A-ABB2-87A067E20D0B">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="CE3407B1-47AC-4FD6-9E06-A30469B42633">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="4C45671B-A717-4A39-93D9-67212F504BEE">
                  <SHORT-NAME>Dlog</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="5F6B2989-0B16-4D67-819B-438C0293E74E">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="2A28BA2B-4BCC-40F4-AEEE-64FA9AF2156B">
              <SHORT-NAME>Darh</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="627EFE8F-C860-476C-AA64-6DA356E0E66E">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="440924E6-E2DE-430A-BE74-CD791DF99A25">
                  <SHORT-NAME>Dcm</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="46F8965D-0FE7-4662-9D8B-96C5A7C1512E">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="74F90C6C-BB99-4E44-9147-CD6C7576B5D4">
                      <SHORT-NAME>DataConstrs</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="AC915132-95AD-4A87-BB11-D8177AF5DCB4">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="174AA54D-4717-4260-8FD8-411038817C89">
                  <SHORT-NAME>Dem</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="54DCD434-E617-4A35-87FF-68483ED45613">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="BBD2DC0C-CA5F-41DE-AD2A-2785CDE70CEA">
                      <SHORT-NAME>DataConstrs</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="DFEA0EAC-6192-43FD-B6D8-FA66AA760B35">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="ACBC588E-EECA-4AE5-B137-3A28F738656E">
                  <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="BB5ECFC6-9396-40F8-9AE3-1C358FB3F7FD">
                  <SHORT-NAME>NvM</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="3F06821A-DF28-4630-BC20-59D8DF6F0182">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="1A4CF4FB-4F7B-4DCC-933B-608289A4E156">
                      <SHORT-NAME>DataConstrs</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="FB5C6037-B976-407A-974E-03840FA42520">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="CBCB2624-C7AF-4516-9DFD-1B9BCF98A294">
              <SHORT-NAME>Dlog</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="8B482CCB-7251-440E-826B-AE586CB69DF5">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="909A6061-18D8-418E-BB0E-B48896F9F359">
                  <SHORT-NAME>Dcm</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="2217D552-2159-4776-AE58-5B4FCF0A4879">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="705E4086-7DDA-429C-AF9C-C75E912BAD36">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="1A2F1C1B-EB56-4B84-A3B0-2D9CB1242292">
                  <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="FD5E75A5-0CDD-45F9-A4AC-B43AF9A5BAAA">
                  <SHORT-NAME>NvM</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="183C2094-8387-4473-BDB7-D306B872CFFE">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="A1AFA339-DE8E-44A8-B54D-BE10BE4553A6">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="86AFE863-665F-4EE4-9E37-99F6931F67A2">
              <SHORT-NAME>Omc</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="E1659F57-8870-4AEE-966F-1E2AD0691A17">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="BB34CBD6-51E1-4FFA-A2FC-311E68F467E9">
                  <SHORT-NAME>Dcm</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="691DA079-78DA-485D-9EC9-126A89D2F4F8">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="A862CFA8-47E6-4847-AC8E-B6B195B1BFDF">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="7A81D61F-E180-4BC2-B3F2-ED6FCA3E5C0E">
                  <SHORT-NAME>Dem</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="DF35AD7B-5639-4275-BEE1-4FCE61E89FD3">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="D742091F-1DF3-4645-ABB2-FA28C037F107">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="5004AD17-DA6E-42D7-A669-0726105BBEEA">
                  <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="CFC65550-F912-4D7E-99D2-AECE06C3BC21">
                  <SHORT-NAME>NvM</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="7C7F5AF9-236D-41D3-AE7D-5128CE1B3B26">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="15B8FFF5-2041-4CC1-8F2D-347DBD89F9AE">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="FEE9F0CE-3107-4D7F-98FA-8026072CCEB7">
              <SHORT-NAME>StdDiag</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="2A3E8D3A-A4C6-48AE-B67D-D9851C86E102">
                  <SHORT-NAME>Coding</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="1AC681F1-6F82-452C-8733-79AE2D7ED814">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="D16AB1A7-5AEE-49D6-BBFA-2ACACC1EBEC5">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="6C71FD18-3475-4A24-B5A9-4168B602DDD0">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="71DD332B-A611-49A6-B8C4-62ED602F16CD">
                  <SHORT-NAME>Dcm</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="C3DADCAA-CF40-4BD3-A78C-5FE3F0837B12">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="91779B03-8BF8-4E3C-AE68-CF4F7591FB56">
                      <SHORT-NAME>DataConstrs</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="254F44C9-5EEF-46F9-8234-9E759A68B1A6">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="FE7B2F7D-C3CD-4478-BE0B-FA15C2DB2A4E">
                  <SHORT-NAME>Dem</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="E02F3864-1D10-42F9-ABAA-A219D7333503">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="23BFC2A9-3DE9-4D5E-9C7B-4CBA131CDA03">
                      <SHORT-NAME>DataConstrs</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="28CCF768-6583-4487-95C3-63A7BEDA1199">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="B155C161-AF43-4E02-A825-4C04DE94C41A">
                  <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="168FFF9D-49DD-4F45-9272-959843B93277">
                  <SHORT-NAME>Omc</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="FED9CFC4-C17C-442C-A8F3-A4A79905A356">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="A6C2D074-9678-4D2D-BAFD-6B9512A1F236">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="359C0298-8D03-4A5E-8551-CFD5A1A69780">
              <SHORT-NAME>Stm</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="B39F5F44-17B5-42B1-80A3-FF930EEC449D">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="A4DF1B80-F92E-4C2B-A708-9622131017EF">
                  <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="48737B9A-0DA1-49D6-91F0-2558ED8BB948">
              <SHORT-NAME>SysTime</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="D2F8359E-C7EE-4CED-B655-C474B8CE81B2">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="D4239F16-2AF6-47C4-A889-344DC7B6DAC3">
                  <SHORT-NAME>Dcm</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="FE73563A-CC4E-49F8-9BDB-5584F6CDC0F3">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="6DBD017B-1BD4-494D-A0E7-0233B7B90132">
                  <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="147A8ACF-4786-4F62-B633-32B241C53F05">
              <SHORT-NAME>Vin</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="AD979F66-9427-4D22-ADA9-50D4F6117CF7">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="49A369BB-7E23-43DA-A4BC-97BD8BD05020">
                  <SHORT-NAME>Dem</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="D1B490E0-01CA-4567-87FF-4B89FD9BC104">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="3268885E-576A-4E9C-82F3-7B8A2B581730">
                      <SHORT-NAME>DataConstrs</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="0D71C4BE-A135-47B0-97A1-24E0CE981D7D">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="C9C2964D-C847-49A5-A94B-08C5277E9E11">
                  <SHORT-NAME>Dlog</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="8A396911-A5C3-42A0-A6E3-BF50E2222C48">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="8D75E5F4-3EF5-45A4-A861-07B573447F4E">
                  <SHORT-NAME>Fscsm</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="6193DF32-C77F-483C-93B4-C25729A426FE">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="EAD3724A-FFE7-477F-94E8-F1FD11F7D7A5">
                  <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="4AC76937-CDA7-41A8-A700-0E629B400134">
                  <SHORT-NAME>NvM</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="E779EFA5-D570-412C-AD76-2FD27947ADF8">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="A396303E-F96B-42FF-9E0D-F7331E685F70">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="BB1A49EE-88B5-43B1-9957-3E996906FD76">
          <SHORT-NAME>SystemDescription</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="0FB5E5EE-42BF-428F-B20C-FD4C2DF8D98C">
              <SHORT-NAME>BaseTypes</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="FA4D49C4-1C47-48A9-AC3C-D900C00E9FC9">
              <SHORT-NAME>CompuMethods</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="1FAB8448-CE5B-4981-8E39-230BE33AE5B0">
              <SHORT-NAME>DataConstrs</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="28860234-41C5-4D87-A317-3C611D27F9E8">
              <SHORT-NAME>Units</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="55873589-E0EE-403C-BE51-2DD3B5B55953">
      <SHORT-NAME>ComponentTypes</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="C6B49A8D-2381-44BA-B800-287FF63CED2E">
          <SHORT-NAME>ConstantMappingSets</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="724F61EC-1404-4369-BD78-CC7DF8F21376">
          <SHORT-NAME>DataTypeMappingSets</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="D696BFEA-50C5-45C2-B3CB-52579CDDB1D6">
      <SHORT-NAME>Constants</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="81921ABE-717A-4504-A384-5E28E8CC33F0">
      <SHORT-NAME>DataTypes</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="1C9DB839-D710-4DDD-81EB-082B473FFE7B">
          <SHORT-NAME>BaseTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="44D2635A-1873-4CA1-9257-B468B14BAD99">
          <SHORT-NAME>CompuMethods</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="E4994FC5-3606-4713-B47E-E9B2AD0242D7">
          <SHORT-NAME>DataConstrs</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="EFBC2479-D585-4F8F-8CFB-F408DDE17CA0">
          <SHORT-NAME>PlatformTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="7FBB2E0A-B5B0-454F-8C64-C01A7C23CD8B">
          <SHORT-NAME>Units</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="AB15681F-F7E2-4301-86FA-9019F9759B2C">
      <SHORT-NAME>ECUCompositions</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="4A623C62-0F7A-41FE-98EF-3877C757A0DE">
      <SHORT-NAME>ECUCompositionTypes</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="EAA1D10F-D085-42BF-A063-7A18FDB43B6A">
      <SHORT-NAME>EndToEndProtections</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="887D1CEC-CDE3-48FE-A974-2D512B54F5A5">
      <SHORT-NAME>MICROSAR_SWCS_DEV</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="F979BF65-883C-4664-9172-16812930068A">
          <SHORT-NAME>BswM_swc</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="F311EE30-1DCD-4D0D-B825-95DB52350DEA">
          <SHORT-NAME>Dem_swc</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="AC5748B1-0348-4927-9CAC-B2B015D737DE">
              <SHORT-NAME>DataTypes</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="0CEDBD0F-F3B0-4493-98E9-C1AD75EECBD1">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="611D6C2B-E7A6-484C-8333-7D02AED7192B">
                  <SHORT-NAME>DataConstrs</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="A8D5D169-6D49-4F1D-A51F-D32883EC0B43">
          <SHORT-NAME>EcuM_swc</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="E3BF22B6-BF36-45D4-BDE6-AE72609D8BEA">
              <SHORT-NAME>DataTypes</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="FB3A459E-CEB6-4586-9CC7-E11D43B5F373">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="917656F2-E849-4F9D-870E-33017F20E80D">
                  <SHORT-NAME>DataConstrs</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="C50E847F-7274-4A6F-9CFF-ECC61C9E884A">
          <SHORT-NAME>NvM_swc</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="193CBDC5-9088-472D-9E03-D4D511587DF7">
              <SHORT-NAME>DataTypes</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="5EE08D3B-ED78-4BC2-9C42-431C316C3C23">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="5FAF3AE8-EF2A-4A66-BEF9-79B0F3486863">
                  <SHORT-NAME>DataConstrs</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="153C7F3C-272D-48E4-83E0-7059713E2AD0">
          <SHORT-NAME>Os_swc</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="5BB997B0-D19E-4AC6-BB47-8B250D78780F">
              <SHORT-NAME>DataTypes</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="B77091E5-4C11-4BCB-9085-89562C3A2790">
                  <SHORT-NAME>DataConstrs</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="D1FEFFBC-8DDC-4D6D-8265-472654ECD053">
          <SHORT-NAME>WdgM_swc</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="5CC9A4F4-9183-4BAF-AD04-1D13CD77E071">
              <SHORT-NAME>DataTypes</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="42326406-24FE-419F-806A-DE081AB4F101">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="DA025082-7B24-46C0-B842-8A6369417887">
                  <SHORT-NAME>DataConstrs</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="9EC97662-7F8F-4E3B-A38A-2B7B4475BF94">
      <SHORT-NAME>ModeDclrGroups</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="1973EA8B-65A8-4366-93DF-7A651758E7DA">
      <SHORT-NAME>Nxtr</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="40FA8A58-D827-43FB-9CAA-6566A343F97B">
          <SHORT-NAME>Calibrations</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="B6EED526-EB9C-43E7-948E-327109E2467B">
          <SHORT-NAME>DataConstrs</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="A96F0713-E97F-4677-BDA9-B2836A0CF99E">
          <SHORT-NAME>DataTypeMappingSets</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="4CE70530-D56A-4D39-BD17-926A1815DE03">
          <SHORT-NAME>DataTypes</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="172B6DD5-F18F-4595-BAB7-F2215C69DE97">
              <SHORT-NAME>BaseTypes</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="6BE61242-6303-4D96-966B-6C2DD5B8BBC3">
              <SHORT-NAME>CompuMethods</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="E93F6EFF-381F-456B-9B7F-EC0F9F7B7687">
          <SHORT-NAME>ModeDclrGroups</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="195A7234-2557-4793-ABB0-0C40FDAD13CF">
          <SHORT-NAME>NvMProxy_swc</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="FE7A6B8F-C799-4BC9-921C-3863C16FEB76">
              <SHORT-NAME>DataTypes</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="32451DF4-E60E-4C20-BBCF-0F1C9451CA8D">
                  <SHORT-NAME>BaseTypes</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="8BB9EF3C-6D6C-4E6D-B8C8-146B798121A1">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="58B36C22-C9D0-4C37-9FDB-6DE410F08D66">
                  <SHORT-NAME>DataConstrs</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="2BB26679-94AF-490F-8CCF-25FE8795158B">
          <SHORT-NAME>PortInterfaces</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="F9105805-AE0F-4741-98DA-AC3309A91548">
          <SHORT-NAME>Units</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="7C93988E-0450-4FB4-A1EC-DABBE6247237">
      <SHORT-NAME>PortInterfaces</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="69FB3A02-0BDF-4473-BA20-4E857A9D1438">
      <SHORT-NAME>Predefined_DEV</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="D73682CA-9A00-49EF-9FB5-FAB1B899AC3E">
          <SHORT-NAME>CompuMethods</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="615E6F89-6CFC-4C82-ADD2-27EAA827E291">
          <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="1C204E04-C1F1-4323-824D-EC34939081C4">
      <SHORT-NAME>Systems</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="3209718F-1877-4EE9-B797-7B080701E946">
          <SHORT-NAME>ModeDeclarationGroups</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="CF0FF575-5395-4F6A-8487-A49463C84B18">
              <SHORT-NAME>BasePartialNetworks</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="B306A319-06EF-40A1-8FA3-0386C21D8350">
              <SHORT-NAME>FunctionalPartialNetworks</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
  </AR-PACKAGES>
</AUTOSAR>