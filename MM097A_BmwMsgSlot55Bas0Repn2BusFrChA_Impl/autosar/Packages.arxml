<?xml version="1.0" encoding="utf-8"?>
<!--This file was saved with a tool from Vctr Informatik GmbH-->
<AUTOSAR xsi:schemaLocation="http://autosar.org/schema/r4.0 AUTOSAR_4-0-3.xsd" xmlns="http://autosar.org/schema/r4.0" xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance">
  <AR-PACKAGES>
    <AR-PACKAGE UUID="20BF3A17-1C5D-45E5-828C-11DFFD0E1384">
      <SHORT-NAME>AUTOSAR_Platform</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="C9B7B529-23FA-4661-934C-8AEDE02B63CE">
          <SHORT-NAME>BaseTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="2C3C0B91-A55D-4CC8-B69E-6EBA943EC565">
          <SHORT-NAME>CompuMethods</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="E40F07F5-38F9-48E6-B22A-DC9C21CF4912">
          <SHORT-NAME>DataConstrs</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="36C77C0E-1F79-4E39-887C-E5A8DC16A721">
          <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="6B77E57D-2C9F-443A-ACAD-3AC681B04F41">
      <SHORT-NAME>Blueprints</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="5973249F-9076-474C-A3A4-C466F4376F37">
          <SHORT-NAME>BlueprintMappingSets</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="AFBBDEE0-0827-49D0-B354-F1E62CAADACF">
          <SHORT-NAME>PortPrototypeBlueprints</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="6630E4BC-CBFD-4D44-9F0F-AFF4A7F99E81">
      <SHORT-NAME>BMW</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="25D59E9D-F448-4278-A80A-F24F9327A25C">
          <SHORT-NAME>Boardnet</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="CB6D5515-7F8E-4DC2-B99F-9E298225C5A4">
              <SHORT-NAME>CodingDatatypes</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="1357B380-806F-46F4-BFF9-D80D39A2358D">
                  <SHORT-NAME>CompuMethodsForBoardnet</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="19F91561-B00F-48B9-AC14-33F23342970E">
                  <SHORT-NAME>DataConstraints</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="74423997-242C-4C6D-87B6-E99EC3299EF2">
                  <SHORT-NAME>SwBaseTypes</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="BB905A20-FB3F-4CEC-B236-B83B2397CF92">
          <SHORT-NAME>Platform</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="CD719501-9E76-45B0-BDCC-1BF000CA7A95">
              <SHORT-NAME>Auth</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="0753722D-D6E2-4ED8-AF48-6FDC5FE399E2">
                  <SHORT-NAME>Dcm</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="176C236D-75BA-47FD-A6A8-BBAA5088CB6C">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="0DBC145E-1D61-4F0C-89D8-02AE1F1373DD">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="3D624979-ED89-4844-85CB-FA9E8CFA7451">
                  <SHORT-NAME>Dlog</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="E4B4D0B9-1891-40AC-8249-F0BAB6BCB6B7">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="37A27951-66B2-49F2-9210-DCF74D064192">
              <SHORT-NAME>Darh</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="A5FFA252-FCE4-450F-84C3-3EBBAC646B99">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="DA3F46C3-183F-47A3-A25B-5C0E44A5312A">
                  <SHORT-NAME>Dcm</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="59208C12-07FD-4FA1-807C-58D3D723A00D">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="AFC9ECA5-9716-435D-AA31-FDB375137224">
                      <SHORT-NAME>DataConstrs</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="C4972CB2-384C-4ADF-B2CA-572E8E7A72B8">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="0E032791-00DD-43F1-9A28-E0FD48E5F031">
                  <SHORT-NAME>Dem</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="01800A01-490C-4814-BD45-2C714C05DDC3">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="7DC580E5-2278-4283-971E-33297199A574">
                      <SHORT-NAME>DataConstrs</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="6ED2510C-1AE1-4765-ACD6-5FF483378882">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="C3B04D9A-5BD8-4E52-A6AB-0064745D89F5">
                  <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="D55D89B5-5208-4692-87B0-1D9D2E0E64BF">
                  <SHORT-NAME>NvM</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="E7F53B5D-8D5D-4EB7-9EB4-727684401E35">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="73AE32CF-1A3F-4176-BE12-EAF25847E1D4">
                      <SHORT-NAME>DataConstrs</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="4260AB3A-2156-4C49-AABC-587311FC9041">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="C762DCCB-0B92-415D-8783-B792AEBF65A5">
              <SHORT-NAME>Dlog</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="8081F2C3-AFA6-498E-8FBB-58815FB7EECA">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="C1CD7314-F34A-4F3D-AFD5-E8626AC9D7CF">
                  <SHORT-NAME>Dcm</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="3D53A46A-9B14-4982-8FD5-99EB8418F248">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="5BA0BD7A-2CA6-4196-841E-3B7941879E94">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="D2C15F9A-AA33-4462-BEEA-0E658019FA66">
                  <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="A872648F-555D-4F3D-A32B-28048E44B5C7">
                  <SHORT-NAME>NvM</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="CC8C382B-2608-4288-BB4B-DAADEF25DCC5">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="A9D83791-DDD1-4861-B6D3-B0EC04D8373F">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="2AEDAE3E-CC5A-4C19-A721-C2BDC80A2DCD">
              <SHORT-NAME>Omc</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="ED724B83-0EC6-40A0-B8D5-E793376B495B">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="02E5766D-C4F3-41A5-BA55-B8494978CA0F">
                  <SHORT-NAME>Dcm</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="5AB66013-12AE-4EB7-84E3-950DF6F5F1CB">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="2454E9C0-A105-40DC-829E-E69362B9A355">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="3BCA5082-4C6B-4716-8684-84EEA9F742FB">
                  <SHORT-NAME>Dem</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="8E3DCC0F-FBDD-43EE-9503-0889E7C29C3F">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="862E7246-C8E2-42F8-A4CF-C7E3616F6D81">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="97653C1A-7A73-4C08-A776-8C8833713517">
                  <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="E018437C-A84E-4AE7-B602-1298B8C5B5CA">
                  <SHORT-NAME>NvM</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="A1FB9C71-92D5-4AB3-8930-FB9B035DDAF6">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="A59089AB-69D9-49D4-9465-2DBDECAA1809">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="18690F8E-7C09-4C00-8E70-86A6D50811F1">
              <SHORT-NAME>StdDiag</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="B305D0E8-BF84-44F3-8D07-A9277F170911">
                  <SHORT-NAME>Coding</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="0769BF23-97E5-4AF9-83B0-B0A7E9F118DF">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="878BDBA6-4FD0-4DAC-9DA4-528AFB81DF58">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="5918895A-9F5B-42CB-835D-A888F5CECD83">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="9323B0CA-E7F6-4214-A474-DC03EE8E73D9">
                  <SHORT-NAME>Dcm</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="5E480C11-8B5A-40E2-84B6-3878C4ADC387">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="31D8C1A1-22A7-48F2-8EB7-2CBC5C99C985">
                      <SHORT-NAME>DataConstrs</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="95BB1517-2744-4E79-921B-5396AABABF86">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="8E4CAE0D-BB7F-4279-88FF-C0BD31E42006">
                  <SHORT-NAME>Dem</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="7E7C7393-E8BA-4B3D-AF9B-A7AE5C685DBD">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="236E1EA9-0837-4EF7-B360-86054199AB2F">
                      <SHORT-NAME>DataConstrs</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="FEF5FF59-1142-4E45-BB6A-9EB95732E19F">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="73A25491-7D18-4E13-A236-9EC0814A040D">
                  <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="D0BA79EC-36C6-4EB2-B8CB-3B318D3E940A">
                  <SHORT-NAME>Omc</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="C80B82E8-0897-41E4-AC18-E420495D1897">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="8D45A85B-3195-461F-8B90-156D38D2F0A5">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="FC53B5C3-71BC-4E46-9ECE-3541D543F52E">
              <SHORT-NAME>Stm</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="4E88DDF7-C2EC-4F43-B1C8-1D54D30C7CDB">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="49D70A93-2183-499C-8135-EE7F070F77C2">
                  <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="AC42B03A-BFED-4449-B698-F0BB20364840">
              <SHORT-NAME>SysTime</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="2E59DB82-8F6A-4FAB-8420-7E80F4A058FC">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="07DAFAE4-6CFD-4605-8300-3972DDFCEEA0">
                  <SHORT-NAME>Dcm</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="1546DEA5-FFEB-44F9-878E-6F180A0FCCEB">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="0E66C88A-C625-4B08-A918-47A0F283B8AD">
                  <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="4A0720FA-CD30-4F7B-90D0-B046A3046F30">
              <SHORT-NAME>Vin</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="56B5924B-0271-4380-BB96-74D10BC88320">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="413FE087-6DDD-4AE3-8B86-0C6CA9B865AC">
                  <SHORT-NAME>Dem</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="C7025B4A-70F8-42A5-A60E-9FA5A17FBAD6">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="EB485C9E-F147-4098-9A6F-FAF3B267DDD4">
                      <SHORT-NAME>DataConstrs</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="D5C60D0C-D24D-4074-AF81-28825426F32B">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="E75D6B61-D625-4E60-8068-BE6EE3342133">
                  <SHORT-NAME>Dlog</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="BF45022C-FD3F-4EA9-AEDF-413AC39D9BC8">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="5043E8B4-421F-479D-96FE-4FFBF9AB5312">
                  <SHORT-NAME>Fscsm</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="0A247331-4C46-482B-AFA8-CBF22E3FBE35">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="228B60BF-B0B7-4435-AC3A-A3E27503A9D1">
                  <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="AD6D2A70-E91C-4CB2-9327-BF92B91BEABF">
                  <SHORT-NAME>NvM</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="718E208A-1AAF-4584-99E4-F9BA8AAB72C6">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="698CCBE6-4D56-4735-A99F-4C2EDABF4E18">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="4909A392-7BC2-4508-90E8-4BF67FE856A0">
          <SHORT-NAME>SystemDescription</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="0E61593E-8382-4017-831A-43105745E5FD">
              <SHORT-NAME>BaseTypes</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="FAD12003-60C1-4997-BEC6-985F8AD51DA9">
              <SHORT-NAME>CompuMethods</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="313EB0E4-97F0-4382-BDB1-32E98AE89F07">
              <SHORT-NAME>DataConstrs</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="120ACD95-C864-42D5-8BFE-EC70EB511C57">
              <SHORT-NAME>Units</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="55873589-E0EE-403C-BE51-2DD3B5B55953">
      <SHORT-NAME>ComponentTypes</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="C6B49A8D-2381-44BA-B800-287FF63CED2E">
          <SHORT-NAME>ConstantMappingSets</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="724F61EC-1404-4369-BD78-CC7DF8F21376">
          <SHORT-NAME>DataTypeMappingSets</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="D696BFEA-50C5-45C2-B3CB-52579CDDB1D6">
      <SHORT-NAME>Constants</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="F7E0B8B5-7B39-45C9-BE18-015FBD9BEB7B">
      <SHORT-NAME>DataTypes</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="2F0A2D93-CDB9-4253-AF91-18DAC0AF8682">
          <SHORT-NAME>BaseTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="44D2635A-1873-4CA1-9257-B468B14BAD99">
          <SHORT-NAME>CompuMethods</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="3ACE2EF2-4DFC-4294-A032-0A6D7186CEA7">
          <SHORT-NAME>DataConstrs</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="F133A9DD-5822-4AC6-BBA8-47708F82F252">
          <SHORT-NAME>PlatformTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="7FBB2E0A-B5B0-454F-8C64-C01A7C23CD8B">
          <SHORT-NAME>Units</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="AB15681F-F7E2-4301-86FA-9019F9759B2C">
      <SHORT-NAME>ECUCompositions</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="4A623C62-0F7A-41FE-98EF-3877C757A0DE">
      <SHORT-NAME>ECUCompositionTypes</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="EAA1D10F-D085-42BF-A063-7A18FDB43B6A">
      <SHORT-NAME>EndToEndProtections</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="79C11EDD-1A03-4377-9E23-EC3225654CE5">
      <SHORT-NAME>MICROSAR_SWCS_DEV</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="21C0F21A-6C4D-42F8-854A-B862FF1E6457">
          <SHORT-NAME>BswM_swc</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="B3896B37-81F6-4770-9E74-E4468D1EFBC2">
          <SHORT-NAME>Dem_swc</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="CDE910BD-40D3-4C57-B092-E3DDDC5E1BFE">
              <SHORT-NAME>DataTypes</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="4E0E4F04-3A43-4136-85F0-BE7C6753EB87">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="E35FABED-FE1D-448C-8505-1C4E2F875B35">
                  <SHORT-NAME>DataConstrs</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="5045DE53-D540-4F1B-8019-016C522BEDB5">
          <SHORT-NAME>EcuM_swc</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="B0DAC838-EE23-40B3-A5B2-4E422220D124">
              <SHORT-NAME>DataTypes</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="A7A67680-6959-4A8D-BD15-604A742257B0">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="5D128DCD-DA80-4C23-887B-7883CF28FC21">
                  <SHORT-NAME>DataConstrs</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="F4A9DB9E-B9DB-4745-AB7B-CF700BCB9B68">
          <SHORT-NAME>NvM_swc</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="70B3C158-54E3-4778-B25D-D0FD55B7FC9A">
              <SHORT-NAME>DataTypes</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="3D9EFBF4-D708-4AC8-A1BC-8BA4D720D80E">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="1B9CDCFB-C234-48E6-AB42-1492CC3F5177">
                  <SHORT-NAME>DataConstrs</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="85992645-5D99-4D1E-AF47-FC712229EA4E">
          <SHORT-NAME>Os_swc</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="D465365D-8C68-49A0-90BF-ECF87E4CD8EA">
              <SHORT-NAME>DataTypes</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="74DD0C19-DBDB-4129-9CCB-4AB44EC098D5">
                  <SHORT-NAME>DataConstrs</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="24F35E63-0D01-4E47-B211-736237119629">
          <SHORT-NAME>WdgM_swc</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="EA51BCEE-2A14-48B3-A160-4585E887F94B">
              <SHORT-NAME>DataTypes</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="981211A4-B0EA-44A8-A314-723B0A69E16E">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="8E54F138-72C5-46BE-ADD9-E15587138CDC">
                  <SHORT-NAME>DataConstrs</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="9EC97662-7F8F-4E3B-A38A-2B7B4475BF94">
      <SHORT-NAME>ModeDclrGroups</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="DE5E9127-EF4F-4936-8F35-4380ED4CF655">
      <SHORT-NAME>Nxtr</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="40FA8A58-D827-43FB-9CAA-6566A343F97B">
          <SHORT-NAME>Calibrations</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="349F97C0-D350-4E5E-9044-D4A42A6E5875">
          <SHORT-NAME>DataConstrs</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="6C4349AB-6464-4039-995C-03DCE54648D7">
          <SHORT-NAME>DataTypeMappingSets</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="0A006DDC-7F2A-42A2-B4AE-42537FC70BD2">
          <SHORT-NAME>DataTypes</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="172B6DD5-F18F-4595-BAB7-F2215C69DE97">
              <SHORT-NAME>BaseTypes</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="B7FFE015-1BB4-4026-99DC-4ED7DE203344">
              <SHORT-NAME>CompuMethods</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="E93F6EFF-381F-456B-9B7F-EC0F9F7B7687">
          <SHORT-NAME>ModeDclrGroups</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="A0173A6C-DB39-4910-8E3E-FADB24F662EF">
          <SHORT-NAME>NvMProxy_swc</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="EA94CAA9-24FB-4390-81FD-C3FF14F85F79">
              <SHORT-NAME>DataTypes</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="E4836E45-1378-4407-81AA-C33617AA2561">
                  <SHORT-NAME>BaseTypes</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="2DC6A220-BB53-46BC-B113-7FBA8888D18D">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="72B50B96-2AAC-4873-95E0-806F0946FB06">
                  <SHORT-NAME>DataConstrs</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="2BB26679-94AF-490F-8CCF-25FE8795158B">
          <SHORT-NAME>PortInterfaces</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="C7832325-323F-41BD-86B6-7C20751DFA12">
          <SHORT-NAME>Units</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="3D8433B6-4C88-4622-8A6A-CD55338A73EB">
      <SHORT-NAME>PortInterfaces</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="97E1C6D8-0582-4F9D-872A-4F654ED90282">
      <SHORT-NAME>Predefined_DEV</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="68351DAC-918B-4896-B84E-55AA296B6324">
          <SHORT-NAME>CompuMethods</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="A2A8C5FE-1ED5-4B9E-9578-C7A89E3EEF48">
          <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="69DC1C02-60F4-4AEE-A565-A9D5BDB6CED7">
      <SHORT-NAME>Systems</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="EB06248E-FB76-4A87-8E3A-4280A8CC0E59">
          <SHORT-NAME>ModeDeclarationGroups</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="525F55D3-FA1A-46D1-81F7-C16D04626657">
              <SHORT-NAME>BasePartialNetworks</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="BCBB4CA2-3087-4046-8F04-A79C15A98C8F">
              <SHORT-NAME>FunctionalPartialNetworks</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
  </AR-PACKAGES>
</AUTOSAR>