<?xml version="1.0" encoding="utf-8"?>
<!--This file was saved with a tool from Vctr Informatik GmbH-->
<AUTOSAR xsi:schemaLocation="http://autosar.org/schema/r4.0 AUTOSAR_4-0-3.xsd" xmlns="http://autosar.org/schema/r4.0" xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance">
  <AR-PACKAGES>
    <AR-PACKAGE UUID="6DB032F7-C8B4-46E6-BA9E-984E1981D85F">
      <SHORT-NAME>AUTOSAR_Platform</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="1C6D6F63-1CEF-4917-BCE7-FBC8366E4628">
          <SHORT-NAME>BaseTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="88C271C1-8BF6-4CB1-A531-6CCF3317DC04">
          <SHORT-NAME>CompuMethods</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="9E86FACE-2D88-44FD-9DB6-2C255939A73B">
          <SHORT-NAME>DataConstrs</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="3E1F65F2-2635-4AAB-A082-760AEC0FA685">
          <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="6B77E57D-2C9F-443A-ACAD-3AC681B04F41">
      <SHORT-NAME>Blueprints</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="5973249F-9076-474C-A3A4-C466F4376F37">
          <SHORT-NAME>BlueprintMappingSets</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="AFBBDEE0-0827-49D0-B354-F1E62CAADACF">
          <SHORT-NAME>PortPrototypeBlueprints</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="B6871A7B-D683-4980-9D41-4C732E54C5D1">
      <SHORT-NAME>BMW</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="972E7A88-57F1-4FB7-A304-CC27CA50EC0A">
          <SHORT-NAME>Boardnet</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="34CF4D1A-6BAD-4FBE-B88D-3B7A1611F232">
              <SHORT-NAME>CodingDatatypes</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="C8C5E86D-98BE-4417-A261-B08112E31B03">
                  <SHORT-NAME>CompuMethodsForBoardnet</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="829DF630-2689-4E71-AD74-467DFD9FB4A0">
                  <SHORT-NAME>DataConstraints</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="B3BF9B85-8408-42A4-829C-45F68FB896BE">
                  <SHORT-NAME>SwBaseTypes</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="C0B5AD99-5D7E-4AD7-AEBD-BA56EE7E3169">
          <SHORT-NAME>Platform</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="7EF591DB-1576-4D5E-8B55-7284D027114A">
              <SHORT-NAME>Auth</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="5DCF2D20-51D8-4C00-A154-CBD89C3FEA2F">
                  <SHORT-NAME>Dcm</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="E0829920-BAE8-408C-9DB6-B038F4327275">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="D1A41022-ED37-460D-A7A1-648361764547">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="9214A5CB-2D12-46F8-8FED-C854185A7D01">
                      <SHORT-NAME>PortInterfaces</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="D25E23A4-A3A9-4C49-9C9E-42BCDBBB4543">
                  <SHORT-NAME>Dlog</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="7D3EB1FF-4051-4B41-9956-CD26E0A088A4">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="A5D2BA40-7872-4A9E-A0C5-553520D235A9">
                      <SHORT-NAME>PortInterfaces</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="A155B4AE-5806-41D2-8F29-1D31848AE263">
              <SHORT-NAME>Coding</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="C6D92C49-AC73-4F21-9E0C-9B402F0EA489">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="F8562982-1E90-4559-8B0C-067C4DC18A71">
                  <SHORT-NAME>DataTypeMappingSets</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="0A424255-2099-49AC-A77C-CFDC43AC6397">
                  <SHORT-NAME>Dcm</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="415FAF1C-3CAE-4482-8097-8AC49377433B">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="298DF35D-F79C-43B2-BEB6-15E3A77E9E04">
                      <SHORT-NAME>DataConstrs</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="59A3B210-F556-454C-ACAA-A54D1121097E">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="80FF2739-394A-445A-9A44-3A6B010F7BEF">
                      <SHORT-NAME>PortInterfaces</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="B90AD633-A31A-4B33-A779-08C360055397">
                  <SHORT-NAME>Dem</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="C80C096C-B1EF-49CB-9A5B-6A386384834D">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="2766D7DC-A1E9-41BF-9F7C-98B3864A7121">
                      <SHORT-NAME>DataConstrs</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="F845C30E-55CB-4C09-8EA4-31BFDBDFB443">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="4C945ED4-4184-4EB1-8789-EFD0E180296F">
                      <SHORT-NAME>PortInterfaces</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="F18868E5-625B-4BB1-AA01-D3B592E9AB2C">
                  <SHORT-NAME>Dlog</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="B766835C-284B-4843-A786-F0C978E71E4A">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="E1EFD215-CB55-44EE-BE6E-836DA26A6AF0">
                      <SHORT-NAME>PortInterfaces</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="0DCB844C-E030-4519-9455-A0E2E62E14D8">
                  <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="75563CE2-296B-4B8A-A81C-1965F448F3A1">
                  <SHORT-NAME>ModeDeclarationGroups</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="8520EA80-FCE7-4037-AA57-081C82CBA008">
                  <SHORT-NAME>NvM</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="51A206DD-4F44-4727-96E0-D14103BBF6F7">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="95FC4F26-267E-48F2-A525-44FD4FC14DF0">
                      <SHORT-NAME>DataConstrs</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="F2CF77CF-4DC1-4383-B921-20BF59E46456">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="62BF0230-3E52-4453-AA80-1D016F36849B">
                      <SHORT-NAME>PortInterfaces</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="71DD0DE2-BDDD-4544-9114-7DEBE071946F">
                  <SHORT-NAME>PortInterfaces</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="B47D5F8C-0E50-43C8-B9CE-33FBF63821F7">
                  <SHORT-NAME>Vin</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="1CA7A9FB-53AF-4B28-AAF5-07675FE70E07">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="865EAC05-C776-4593-983B-F09ABB8BE8A3">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="1EDDEFB1-A6F9-4275-A744-A494A688B30F">
                      <SHORT-NAME>PortInterfaces</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="BBF0C0F8-BA84-400E-A8BD-7DF332DC984D">
              <SHORT-NAME>Darh</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="061964D8-CD87-431E-A324-C134D1E422FB">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="6F5F38F5-8272-46ED-B69D-D28CDFEA453D">
                  <SHORT-NAME>DataTypeMappingSets</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="EB4E755E-935B-4D3D-A7E5-CF78BDAF47DE">
                  <SHORT-NAME>Dcm</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="219E2F1B-BEA1-461A-806F-1637FE2B362B">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="2D0C53CC-969D-43CC-96A6-ED6944FCEFA3">
                      <SHORT-NAME>DataConstrs</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="AC64FA73-5D35-4AA1-B11C-6BFC7E4C26DA">
                      <SHORT-NAME>DataTypeMappingSets</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="FB872092-5BCC-4FAC-B5C3-9C88CC9A6F7C">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="EAEDB751-8CDF-43DC-BC1D-95199A46A310">
                      <SHORT-NAME>ModeDeclarationGroups</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="E15D994B-DA69-4920-BEB9-67596BDCB6E2">
                      <SHORT-NAME>PortInterfaces</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="FC9D1CF8-E7C6-4359-8875-FB594D64654C">
                  <SHORT-NAME>Dem</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="50A120BB-866F-41C5-AA77-9D781642906A">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="9411783C-9B3A-4A8D-B59F-347ACA76D442">
                      <SHORT-NAME>DataConstrs</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="FC86FA11-6AB5-450F-A222-DB090FF7D4C1">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="04850100-E79E-4357-86CC-17A6DD2AB70D">
                      <SHORT-NAME>PortInterfaces</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="41A30728-7992-4D70-BD88-392A3CCDDE5E">
                  <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="C37F1A79-66CE-4164-9229-8175BCDF7CE7">
                  <SHORT-NAME>ModeDeclarationGroups</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="E541C052-4A72-4C44-8E08-5E53E00B46D4">
                  <SHORT-NAME>NvM</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="9BED2BFB-510F-4D36-962F-D2CBEE375682">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="20C4C405-F664-4506-8159-87E87462EC9C">
                      <SHORT-NAME>DataConstrs</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="C52B2651-95C6-469E-95E6-DB394E1DC3DE">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="B221BF55-2C3C-4C26-9ADF-65BE49C8BDD2">
                      <SHORT-NAME>PortInterfaces</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="506FC36F-7247-4F31-B420-AC257E9D74F7">
                  <SHORT-NAME>PortInterfaces</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="69278A35-C075-4158-9EA1-C8C0C39FC247">
                  <SHORT-NAME>Tp</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="6F1F9E35-5281-4759-817A-A957E9AFE31B">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="C1CF8491-19A3-4561-B87C-D07252B6B1FB">
                      <SHORT-NAME>PortInterfaces</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="71B940A9-5060-4832-BF5A-97187EE6F2F5">
              <SHORT-NAME>Dlog</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="60FAB8F5-A4A6-4FE7-84D9-57F825B86395">
                  <SHORT-NAME>Coding</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="04B54D2F-D11A-48AA-9AC5-240CED783EAE">
                      <SHORT-NAME>PortInterfaces</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="64D36FEB-11D5-44A0-A302-06FEE3079C4A">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="0CE49CB3-7509-4BF9-A0A8-C6C71C793EDA">
                  <SHORT-NAME>DataTypeMappingSets</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="C0B745BF-5393-4432-806A-CCB979F8AF93">
                  <SHORT-NAME>Dcm</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="2BC5C662-A92A-4EFA-8728-E7FB98CEF44B">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="D658C105-33AC-4F77-8AD7-6A09E8D679BD">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="26E0FCDA-D6FD-4A8F-AE88-4329B9317299">
                      <SHORT-NAME>PortInterfaces</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="F5958F3C-5136-447A-8240-2841A92369BE">
                  <SHORT-NAME>Det</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="CEE12171-151B-48F0-AE6E-76B1D8D7DCC0">
                      <SHORT-NAME>PortInterfaces</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="BAC0D70D-AB71-4AA4-A019-9A853D49FB14">
                  <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="6438D509-9A81-4811-8DB9-3DC01B7A5B3C">
                  <SHORT-NAME>ModeDeclarationGroups</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="0D31D5E2-3199-4921-805F-62B97D412112">
                  <SHORT-NAME>NvM</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="91C1C765-25A8-4754-8413-2E8FEA57D1DE">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="09F1065C-C7E5-421F-A305-8B463CC7A603">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="05B6BC32-1413-4A75-BE2E-0929B0618F3A">
                      <SHORT-NAME>PortInterfaces</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="99D78A3A-BED3-47FA-9570-7C2DAE29AAA2">
                  <SHORT-NAME>PortInterfaces</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="FFB14AFE-8DA6-43F5-9AA4-3CC75DFF61D0">
              <SHORT-NAME>Omc</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="848EE4DB-9022-4AD7-9BA5-A79B3BC93B63">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="8EE8A8B7-1658-4558-874E-51247D34407D">
                  <SHORT-NAME>DataTypeMappingSets</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="F6E9D3C4-C221-4F12-B1A2-4B0AC7F70948">
                  <SHORT-NAME>Dcm</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="810D9003-8841-4648-9640-5D902CEE427C">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="7AB4B7C3-3DB2-44FE-87DD-6FD031A46305">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="F9D738BF-B41E-4583-B36F-6873F0631CB7">
                      <SHORT-NAME>PortInterfaces</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="F549D8D4-BB79-4AE7-8FFD-C79326B63238">
                  <SHORT-NAME>Dem</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="945A5A80-81D7-457B-9B06-1203B63D7A6F">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="D6A30EE3-4D52-470F-9C6D-D08C8E3E0BE0">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="8C25D284-CCF0-4F2F-9B4C-4D213DE04222">
                      <SHORT-NAME>PortInterfaces</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="869665F7-AB83-4BCA-9486-CD2C9A80E8DB">
                  <SHORT-NAME>Det</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="D564DA85-34D1-4E0A-B9A7-CF131A27EC57">
                      <SHORT-NAME>PortInterfaces</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="766557FF-E62E-4E27-A7BE-3AB678E622A6">
                  <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="A9EEB593-B0ED-4F2C-A3CF-B08584AB8F34">
                  <SHORT-NAME>ModeDeclarationGroups</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="B72A9FB0-1965-42BB-B4D8-6C0A0D49A266">
                  <SHORT-NAME>NvM</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="4A027268-6BFE-48FB-A9C6-DCCCB81EB02C">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="9E900F32-87DE-4EE1-8388-240781F5B0B8">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="51377074-1216-4344-ACE9-7EADC07A387C">
                      <SHORT-NAME>PortInterfaces</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="FBB71A25-72B2-486F-9051-27D3B283AF7F">
                  <SHORT-NAME>PortInterfaces</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="4E7F7C80-60CE-47A9-B726-F40A8174C7A8">
              <SHORT-NAME>Rmh</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="B760C7E0-49E4-4FBF-A910-D912B3C17C7D">
                  <SHORT-NAME>PortInterfaces</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="24E54493-F89B-484B-9F88-340FCE6436E2">
              <SHORT-NAME>StdDiag</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="976E3BDF-9C80-4271-85D6-0A95FD5935CA">
                  <SHORT-NAME>Coding</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="2FCC5171-F20D-4804-9290-1AC9ECBF8DA4">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="0BDE6481-67FB-41DA-B5D8-874F7F4C4798">
                      <SHORT-NAME>DataTypeMappingSets</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="D298A341-5802-4C38-AD6C-6B7CE8D0AC4E">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="F495A327-F612-409E-A659-1FD77BA39652">
                      <SHORT-NAME>ModeDeclarationGroups</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="FD52EC7A-1A2B-4CA4-8D45-51B5E40663E4">
                      <SHORT-NAME>PortInterfaces</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="E410BA52-7E84-4D9F-B968-F2938E82D769">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="66345D5A-7C96-4469-AE58-6AFB1BD81874">
                  <SHORT-NAME>Darh</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="F427FAA6-D8C4-4A4B-B683-B683F8BB828E">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="343B7276-618A-478A-9C34-08006D478821">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="5EBCB2C1-0A84-4660-81C3-53EBAD0FC0E3">
                      <SHORT-NAME>PortInterfaces</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="79CFCC0F-EC77-4195-B7F8-F6EE74AABB89">
                  <SHORT-NAME>DataTypeMappingSets</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="04DF97D4-AC86-40D7-9C58-6EF330501E0D">
                  <SHORT-NAME>Dcm</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="DBF375B3-AA3D-4795-AB90-A95E88E14721">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="ADE4016D-DD2E-4C0D-8DEC-38B31A85156D">
                      <SHORT-NAME>DataConstrs</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="7DA3CEA3-4BA2-4364-9BEF-0B73CE5C7AC1">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="41E249AB-8DDC-4205-97AB-19523FE8B833">
                      <SHORT-NAME>PortInterfaces</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="B069BB26-4E14-4A37-9ADC-61F6C40A7534">
                  <SHORT-NAME>Dem</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="8605C101-0223-461B-8830-8BC7509D44B3">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="CDA4A83E-6660-429A-A338-2AB57470502B">
                      <SHORT-NAME>DataConstrs</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="7AE2F165-3495-4547-ABAE-9601CFE04EC9">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="EE1776CC-AABF-45DC-B1A9-C71061326C56">
                      <SHORT-NAME>PortInterfaces</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="3F99C485-2666-4ADC-9E3D-CA2CA39FA8B4">
                  <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="6867DBBB-E4ED-4777-AA3E-7F634A54B12E">
                  <SHORT-NAME>ModeDeclarationGroups</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="3F967197-CB75-4552-B27F-1B3D2F708F9B">
                  <SHORT-NAME>Omc</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="81EE790D-857E-47D4-A8C1-EE582E3B816C">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="0DFB3022-1768-4F52-BC0C-AC97DE637F14">
                      <SHORT-NAME>DataTypeMappingSets</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="C439BF4D-17B7-4AE4-BB2A-F80937816C3E">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="5ED1BA9C-417E-4319-9F7D-218A8179317C">
                      <SHORT-NAME>ModeDeclarationGroups</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="7E0B24AC-4AAD-4687-98F4-84C253FEB771">
                      <SHORT-NAME>PortInterfaces</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="725F8F81-EDCC-4BEE-8A24-52BA83837212">
                  <SHORT-NAME>PortInterfaces</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="EB5E9352-30B8-46D9-9D3A-382B37D09B47">
                  <SHORT-NAME>Stm</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="C5C17651-9825-4819-83FB-12F0B20EBBE1">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="403EF175-E3D1-4538-8273-F05710D46AE1">
                      <SHORT-NAME>DataTypeMappingSets</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="C0A9DBF6-C9FD-42D1-8201-EE6307C6D957">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="B9023293-6BE8-408B-8F1E-54F90DEDE52A">
                      <SHORT-NAME>ModeDeclarationGroups</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="1306D116-5A99-4C0F-9D1C-CA9EC2B28B53">
                      <SHORT-NAME>PortInterfaces</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="4482C0E1-091A-4CD4-A9B0-22FE6C636637">
              <SHORT-NAME>Stm</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="2AE503B3-1BE1-494B-AA3B-7FC0D6542A11">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="4FB6CE8D-3402-4CF9-B685-4C0224446570">
                  <SHORT-NAME>DataTypeMappingSets</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="921ABB11-E73E-40C4-9863-38E783A5AB5B">
                  <SHORT-NAME>Dem</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="A2869D95-6A65-44B5-856B-99CA4E3B2009">
                      <SHORT-NAME>PortInterfaces</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="EBBEF489-7CFA-40C9-9EA0-094BDA1E5155">
                  <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="9C77DD49-93A4-4E1F-BBB4-2240175AEE7C">
                  <SHORT-NAME>ModeDeclarationGroups</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="4B73A81C-1DE4-411F-BD3F-240E04ACE99C">
                  <SHORT-NAME>PortInterfaces</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="328CE871-7411-4FBB-A1E8-4453E58EBCE2">
              <SHORT-NAME>SysTime</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="832B7C29-3C2A-4641-A3E6-34134852B1DE">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="962772D7-3710-4E44-8CD7-07FA702491F0">
                  <SHORT-NAME>DataTypeMappingSets</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="A18692F5-4771-43CD-AB71-D04618CB430B">
                  <SHORT-NAME>Dcm</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="95C61B3D-330C-4CAB-A2A6-D00CCDE9755E">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="AABC3BD9-7E3F-4CB4-9C0C-38541C2014BE">
                      <SHORT-NAME>PortInterfaces</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="12E36F28-67F2-43FD-BEE5-3A5B7F625366">
                  <SHORT-NAME>Det</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="E8B42232-CA01-4B5A-9AF5-EA71A0A0DD4E">
                      <SHORT-NAME>PortInterfaces</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="FC8D0AE1-0680-4AB5-8541-63CF2DC223B4">
                  <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="A95A0EAE-D674-4FB6-BF1A-1947509B8EF3">
                  <SHORT-NAME>ModeDeclarationGroups</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="058B7463-7C49-47DC-ABA6-2A437F8AE174">
                  <SHORT-NAME>PortInterfaces</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="C481FEE6-73D3-4321-BE3E-6CB420CF72A5">
              <SHORT-NAME>Vin</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="53C31EF7-43DA-4064-A7A4-C6D90898E24D">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="F01B6982-94F6-47F4-9015-4FC805542801">
                  <SHORT-NAME>DataTypeMappingSets</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="A7749227-E9DC-4B3C-9308-D0F9AA4FFCE4">
                  <SHORT-NAME>Dem</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="7729B672-E924-4E4C-996A-752A7E7F14A4">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="85F84824-2DB3-4841-AB05-39174CC32303">
                      <SHORT-NAME>DataConstrs</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="C90C645F-2E40-4249-BDC2-D5C9C27123BC">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="46EB6CF4-0524-4AD6-9AF2-1AA8C78C695A">
                      <SHORT-NAME>PortInterfaces</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="32007737-0920-4798-9BAD-4FDF53B8311A">
                  <SHORT-NAME>Det</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="B70D3012-0252-4B92-9776-829E9D97BC8F">
                      <SHORT-NAME>PortInterfaces</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="C32A1474-C78F-42D5-BDD2-2321254A2C87">
                  <SHORT-NAME>Dlog</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="4B2826C3-464B-45EF-98EC-002F645DA814">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="92392A1B-33E6-4452-8504-9A52033ECC0C">
                      <SHORT-NAME>PortInterfaces</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="772E5891-B476-4B2D-8AC8-74D6193D223E">
                  <SHORT-NAME>Fscsm</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="2B904AAA-766C-438A-911B-877551311252">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="B3AF89AD-3D19-4DAD-8AFA-CFDFF84B84A6">
                  <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="10108EFE-3AD0-4451-BB0C-BF42CDE05940">
                  <SHORT-NAME>ModeDeclarationGroups</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="B81D591A-B82A-4FF1-91F1-23804E6E6766">
                  <SHORT-NAME>NvM</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="6AB6D5CF-A5A9-4021-A5FB-50CDA56295D3">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="0B2E75C9-CF84-4AD1-994D-B41929FD2153">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="E545C298-ADCB-44B5-812E-85B43EB14B9A">
                      <SHORT-NAME>PortInterfaces</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="7470756A-361F-4DF5-833B-B339FBDC6FA4">
                  <SHORT-NAME>PortInterfaces</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="42DEEB47-BCFF-4773-A8E3-35D02E2F976B">
          <SHORT-NAME>SystemDescription</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="D286683F-4DDD-4FD2-9AC5-0C0B34CD2328">
              <SHORT-NAME>BaseTypes</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="E942F235-2BF1-4AD0-8299-34CF9A2898EB">
              <SHORT-NAME>CompuMethods</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="4BA0F69E-8FC2-494C-BDDF-B0CB741AAFB5">
              <SHORT-NAME>DataConstrs</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="C7B5DBE9-49CD-44F9-9DF3-1E3E97B987EA">
              <SHORT-NAME>Units</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="DCC3C6FA-1EA5-4CC6-BF5A-6F267EB52B43">
          <SHORT-NAME>Units</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="2090D28C-0DAB-47CB-9D47-1CEDA0C2D075">
      <SHORT-NAME>ComponentTypes</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="C6B49A8D-2381-44BA-B800-287FF63CED2E">
          <SHORT-NAME>ConstantMappingSets</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="98003C39-1648-4D90-8CDA-26AD630B3F0C">
          <SHORT-NAME>DataTypeMappingSets</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="D696BFEA-50C5-45C2-B3CB-52579CDDB1D6">
      <SHORT-NAME>Constants</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="F21B6134-18FE-427C-8794-24315541434A">
      <SHORT-NAME>DataDictionary</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="09FFFA2F-401A-4140-A773-2F20B351CA1D">
          <SHORT-NAME>ComponentTypes</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="DF50D58B-0264-4EF7-BAF5-36D1F552DFDA">
              <SHORT-NAME>DataTypeMappingSets</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="9A9A963E-E8C9-403C-ADCB-22EE25067A83">
          <SHORT-NAME>DataConstrs</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="6FC3C1F1-E6A4-4285-8C5E-5E919EA51B7C">
          <SHORT-NAME>DataTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="CFA3CD03-91CE-4069-AB4C-0686C5AD2DB4">
          <SHORT-NAME>Units</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="F75E2FE4-2237-47DA-8490-37690116D62A">
      <SHORT-NAME>DataTypes</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="1C9DB839-D710-4DDD-81EB-082B473FFE7B">
          <SHORT-NAME>BaseTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="2E64E82C-C6EC-4F04-80F5-CBFCEAFBD9E6">
          <SHORT-NAME>CompuMethods</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="6CB973EA-6513-4304-B797-93E4A56F54BB">
          <SHORT-NAME>DataConstrs</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="1EE1D6C1-FE16-4F67-83F8-F1A64766F7A5">
          <SHORT-NAME>PlatformTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="7FBB2E0A-B5B0-454F-8C64-C01A7C23CD8B">
          <SHORT-NAME>Units</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="AB15681F-F7E2-4301-86FA-9019F9759B2C">
      <SHORT-NAME>ECUCompositions</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="4A623C62-0F7A-41FE-98EF-3877C757A0DE">
      <SHORT-NAME>ECUCompositionTypes</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="EAA1D10F-D085-42BF-A063-7A18FDB43B6A">
      <SHORT-NAME>EndToEndProtections</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="0E9290F3-0290-47EC-AC39-DD4F0E7A16D5">
      <SHORT-NAME>MICROSAR_SWCS_DEV</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="B4C58CA4-3527-4A0A-9D79-D37188F6B77E">
          <SHORT-NAME>BswM_swc</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="6EA3F1A1-5C19-4D10-9D12-B0DF13CD76CE">
          <SHORT-NAME>Dem_swc</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="27498492-D9A3-48CC-B1E1-F162BFD9F916">
              <SHORT-NAME>DataTypes</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="B61BBFA3-932F-430C-ABAF-36F0B2F40C57">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="E4BA8F12-03CB-4899-958E-0CADB50EBA66">
                  <SHORT-NAME>DataConstrs</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="F7CC8BC6-B9B0-439D-8803-DC740BD275A5">
          <SHORT-NAME>EcuM_swc</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="E0C9D94D-8914-4C2E-A93A-B64DBD1FA61F">
              <SHORT-NAME>DataTypes</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="F905430E-EC0C-4385-915E-88EBE0849835">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="B765CA51-EDAC-4CAE-A8C6-752E36855779">
                  <SHORT-NAME>DataConstrs</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="3C0EBD4C-37A4-4E9D-A997-9E8FD92E06A6">
          <SHORT-NAME>NvM_swc</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="851927A2-ABA5-40D2-B923-DB92B2AD4EF6">
              <SHORT-NAME>DataTypes</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="F9B4AF7A-59CA-4614-9B51-3E0B3FA0C4F4">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="B489ED6F-21F4-483A-AFB0-EFEF76D278F3">
                  <SHORT-NAME>DataConstrs</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="2F597FD3-DF89-486D-91C9-E7A2A7DE280E">
          <SHORT-NAME>Os_swc</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="0D71BFC8-FBEB-416C-8F23-07A339D49426">
              <SHORT-NAME>DataTypes</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="6B2CD50E-8EC8-4608-B0F0-13CED0A8E578">
                  <SHORT-NAME>DataConstrs</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="881DC617-91E8-425A-92CD-B1BC74312C95">
          <SHORT-NAME>WdgM_swc</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="C3FC6638-E8DB-4003-8750-6DC8CFCB7AEE">
              <SHORT-NAME>DataTypes</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="C6517553-4CC1-4A2E-A54B-D0E3AF559C3D">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="E60A12D9-4579-4E0E-8A2E-B605B32B2FC6">
                  <SHORT-NAME>DataConstrs</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="9EC97662-7F8F-4E3B-A38A-2B7B4475BF94">
      <SHORT-NAME>ModeDclrGroups</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="4D6D989F-357B-4F6A-AD25-7219228D744A">
      <SHORT-NAME>Nxtr</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="D162EC5A-62E3-4CAF-9646-A3F4E02ACCB6">
          <SHORT-NAME>Calibrations</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="1F039124-D492-4C45-9536-D709A6CA5267">
          <SHORT-NAME>ComponentTypes</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="D82010ED-624D-4666-A126-922BF4C1B1E2">
              <SHORT-NAME>DataTypeMappingSets</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="0EF02F45-C5EF-45F2-9A50-4EA534BE113B">
          <SHORT-NAME>DataConstrs</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="F85E8513-3A5A-456A-94FB-7666B92F049F">
          <SHORT-NAME>DataTypeMappingSets</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="7B724CF5-CE2C-4EE3-90B3-666CEE3AF55D">
          <SHORT-NAME>DataTypes</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="172B6DD5-F18F-4595-BAB7-F2215C69DE97">
              <SHORT-NAME>BaseTypes</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="FA73A719-4826-42DE-8EAC-F5BB5CCDA7A9">
              <SHORT-NAME>CompuMethods</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="E93F6EFF-381F-456B-9B7F-EC0F9F7B7687">
          <SHORT-NAME>ModeDclrGroups</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="2684BA09-5A99-4C24-ACA0-179C8E76164C">
          <SHORT-NAME>NvMProxy_swc</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="EC35D418-CDD7-4588-9E87-856B6D5453EE">
              <SHORT-NAME>DataTypes</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="E95AF3C7-8ADD-46F6-BC35-C724DAC74AE5">
                  <SHORT-NAME>BaseTypes</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="5332529C-9BCC-44E4-8295-8FDFB99F90E2">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="C2042B53-857A-4E55-A97D-6BC3EBE74EF5">
                  <SHORT-NAME>DataConstrs</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="17066C43-019F-4201-9CCC-C420F8A54C46">
          <SHORT-NAME>PortInterfaces</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="95D7F397-FD1B-4620-B7BB-41D91005F275">
          <SHORT-NAME>Units</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="A0AFF046-D9A6-4A7C-9EB1-4F9FB321AD15">
      <SHORT-NAME>PortInterface</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="EB647E99-0D85-4926-8B26-745C69DA9218">
      <SHORT-NAME>PortInterfaces</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="9CD9A5F7-5BB8-4D53-A5A2-29602C51C595">
      <SHORT-NAME>Predefined_DEV</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="CEAED4B9-37F4-4E0C-ACA3-777A95531A13">
          <SHORT-NAME>CompuMethods</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="5624C777-AC73-4F60-A3A6-424B66DA3292">
          <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="057AEE7E-1A6D-4925-9249-F5BB051F856E">
          <SHORT-NAME>PortInterfaces</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="8D7B92F2-E8F4-4E00-B3BA-D09388DEAD9C">
      <SHORT-NAME>Systems</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="DB8BC6F2-BA35-4918-A411-348DD68F247D">
          <SHORT-NAME>DiagnosticSwBaseTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="9B0FF990-BCA7-4834-B2BF-B64B47E95F42">
          <SHORT-NAME>ModeDeclarationGroups</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="069141F2-A582-4AB0-B956-70AB3A7CD9F9">
              <SHORT-NAME>BasePartialNetworks</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="D5D458BD-8E15-4628-9AA6-B364835B38A7">
              <SHORT-NAME>FunctionalPartialNetworks</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
  </AR-PACKAGES>
</AUTOSAR>