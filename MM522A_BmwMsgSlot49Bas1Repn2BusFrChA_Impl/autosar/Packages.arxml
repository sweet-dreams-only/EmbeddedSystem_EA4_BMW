<?xml version="1.0" encoding="utf-8"?>
<!--This file was saved with a tool from Vctr Informatik GmbH-->
<AUTOSAR xsi:schemaLocation="http://autosar.org/schema/r4.0 AUTOSAR_4-0-3.xsd" xmlns="http://autosar.org/schema/r4.0" xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance">
  <AR-PACKAGES>
    <AR-PACKAGE UUID="EA049788-5E14-4B39-A577-C4D3BEB7F403">
      <SHORT-NAME>AUTOSAR_Platform</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="1C6D6F63-1CEF-4917-BCE7-FBC8366E4628">
          <SHORT-NAME>BaseTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="88C271C1-8BF6-4CB1-A531-6CCF3317DC04">
          <SHORT-NAME>CompuMethods</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="070BF8B7-AEBD-4A24-8491-6A8C6D62324A">
          <SHORT-NAME>DataConstrs</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="C1E212B3-9E2B-4B10-AC48-8FA2F96DA634">
          <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="6B77E57D-2C9F-443A-ACAD-3AC681B04F41">
      <SHORT-NAME>Blueprints</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="5973249F-9076-474C-A3A4-C466F4376F37">
          <SHORT-NAME>BlueprintMappingSets</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="AFBBDEE0-0827-49D0-B354-F1E62CAADACF">
          <SHORT-NAME>PortPrototypeBlueprints</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="8A5DDF29-6A02-47B6-ACA5-A42BCE9DC194">
      <SHORT-NAME>BMW</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="17054038-0CB4-467C-89F9-EA269399F499">
          <SHORT-NAME>Boardnet</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="5C77C4EB-3006-4BD6-9B97-06944FC061EE">
              <SHORT-NAME>CodingDatatypes</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="FC623709-2051-411C-9D06-7B5A8B99E7BA">
                  <SHORT-NAME>CompuMethodsForBoardnet</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="984AD027-7A13-4CB6-9FEA-D239A7138554">
                  <SHORT-NAME>DataConstraints</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="217579D0-572D-4EDD-91CA-36860EFB2F4E">
                  <SHORT-NAME>SwBaseTypes</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="DAFDCC5F-9994-40C1-82DA-4D657CF69F1D">
          <SHORT-NAME>Platform</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="A161B1F3-660B-4BE2-A346-AE2217324A06">
              <SHORT-NAME>Auth</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="1706C5F0-4EBC-4FA3-B568-FABB1BBEFFF4">
                  <SHORT-NAME>Dcm</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="E4CF1E4B-38C6-41F2-AB73-7ADD1C3F4466">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="6E1E0A1D-4F05-4EB9-A4B4-F028CEA87F62">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="17EA50F8-2F4B-496B-8FAE-8EB722797544">
                  <SHORT-NAME>Dlog</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="5F8822EA-45A7-4547-9C24-D2238D4A6C3A">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="CEF564FA-D956-425F-903F-C2234C047E09">
              <SHORT-NAME>Darh</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="6C4E77F9-8D2E-45A3-B981-46A4B01822F8">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="2E822916-444B-488F-A8C4-14E4FC8DE023">
                  <SHORT-NAME>Dcm</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="6C5F7DC1-758B-46F8-B4DB-F0600241F284">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="7518C356-0B22-40A7-B662-420ECA59676C">
                      <SHORT-NAME>DataConstrs</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="58D16640-621E-4E50-BAF2-74BCDCECD856">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="243FE647-6714-4178-BE5B-B3BBFB534876">
                  <SHORT-NAME>Dem</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="B838E64D-87D1-409A-9B92-3CA598BCC6E9">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="3A0B4942-43C1-4B21-967A-C82F026C5396">
                      <SHORT-NAME>DataConstrs</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="B2FEC7F3-A941-4CA1-B8E1-EBC165E97921">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="28DEB219-8231-4041-840B-5E8277AF7777">
                  <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="34F7458D-22A1-4B9E-B900-5502A96D8619">
                  <SHORT-NAME>NvM</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="502A501A-3C35-4D46-A655-C6FC22F631BC">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="05990E16-180B-494C-B57A-BFE384684082">
                      <SHORT-NAME>DataConstrs</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="223788E0-607B-4028-BA8B-A8615EE445F7">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="9203970D-F61D-4B3C-A545-D7104C4F90E5">
              <SHORT-NAME>Dlog</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="B52D1ED5-6A0F-4401-A9C1-3A5B9E5856A1">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="69618607-B0C8-489D-86B9-7BE81D99AC20">
                  <SHORT-NAME>Dcm</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="AECC6DAE-5429-4A94-A1E5-7B43D796231A">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="ABAD5AEA-75A9-4BE5-85EC-887D67201BCF">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="2EB85971-081F-4481-826B-7F4543C1C275">
                  <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="82882CFA-AA87-4AAA-BAAD-91FEE41E90B4">
                  <SHORT-NAME>NvM</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="42342F8A-2A2F-4781-9760-E574A040D4BA">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="0CF215EC-E134-4BEA-8194-A8761F606B7F">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="175C03D6-DF2C-4443-BB08-593D10B36943">
              <SHORT-NAME>Omc</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="E07700DB-AFA2-4FF5-BF90-F90E665EF531">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="38B1E526-79D8-4CD8-BC35-82BE1045AEA9">
                  <SHORT-NAME>Dcm</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="73F0F8DB-5853-44F8-8E9F-6B91702B05D0">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="1DF2EAB7-8AEC-491A-8E36-9877A8B36275">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="E6AABCB9-7F4F-431C-83DD-560EECAE0E19">
                  <SHORT-NAME>Dem</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="7070DD52-F861-4C93-B211-BEACF1E809D0">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="A05B7571-BC40-4C70-8003-2ABAB5C49D24">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="E8C23EDE-3929-4859-B76A-AFB10B4C6E52">
                  <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="75034E49-BCCB-4C03-9B1C-F4DE44A17056">
                  <SHORT-NAME>NvM</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="F4B31201-8F4A-4FA0-BDAB-358013BA9A9F">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="38B2F233-D64D-4DBE-9AD5-A2F620F06269">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="AA4C5E78-F810-4AC2-BF58-4CFC485558C1">
              <SHORT-NAME>StdDiag</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="AB0BF3E8-4CF0-4062-8A77-7B08A2E85EA9">
                  <SHORT-NAME>Coding</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="6F48D258-D43B-4436-BEAF-0C321753AFAE">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="87BCECAC-FCD5-4A09-939E-566F578CC5E4">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="C4E33D90-5F1E-4AE7-BD7F-10256ACBCFB4">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="3467ECED-6354-4EE2-A9D6-59D55ECEE8EE">
                  <SHORT-NAME>Dcm</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="42819ED2-2474-4F0A-A9B3-E23D89EE1F74">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="DB596654-9664-47FA-8288-CF7D460C7070">
                      <SHORT-NAME>DataConstrs</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="647193B9-8F45-4915-98AD-88BD72BE820C">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="1D59ECA1-14A2-45EF-B0BC-7F87B04DB407">
                  <SHORT-NAME>Dem</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="E662F4FA-D821-4DB4-A5AC-8611176D8F3F">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="B3ACF4B8-4FA3-41BA-BB01-388004170BE7">
                      <SHORT-NAME>DataConstrs</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="D78CC98F-BF25-4805-A10E-A19436F00D17">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="7F97618B-85D3-43E5-A037-DD249EDF4E3B">
                  <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="312A5670-3335-4A52-9BE3-53D55CC7CB05">
                  <SHORT-NAME>Omc</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="2BE89D19-26A8-4501-897E-9F8CEE913089">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="AEF97985-5E1F-4916-A77F-1BD8A9AA39BC">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="BD844789-9C98-4B72-BE9A-853F6DC79283">
              <SHORT-NAME>Stm</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="BDB9FED5-FDA7-4976-BE4A-1664CEA82562">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="29C1558B-6AE8-4DE5-8DBF-759F5CB6364D">
                  <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="32ECFF21-EB63-419E-859D-7843FDE179D0">
              <SHORT-NAME>SysTime</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="2882297A-E878-496F-8C13-DE076DFA456E">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="32F8B5B7-427E-46BC-833F-5D244DC6F929">
                  <SHORT-NAME>Dcm</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="81993055-0E76-4791-BB01-0D3D7B562AA2">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="A36BA87E-2288-4F58-A4D6-0BEF07A3C87D">
                  <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="7A809196-DD94-458D-A882-D93921D8CF63">
              <SHORT-NAME>Vin</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="9FF184BE-2DF6-44AB-849C-6A78742184A0">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="8AA4C41E-9079-4BBF-9C91-F56CD711AD3F">
                  <SHORT-NAME>Dem</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="E9CB237D-522A-471F-BCEA-0C19F444C319">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="EDF52574-4C2E-46CC-BDC5-776879A53F6C">
                      <SHORT-NAME>DataConstrs</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="7484FF6D-39ED-41D4-8FCC-F31ADA0A3665">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="04561FE8-BF2B-4175-B874-131FF2654E14">
                  <SHORT-NAME>Dlog</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="25421A25-283A-47CA-8375-778C39B195BC">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="5EAC5961-B57A-4A28-96C1-D182715520C5">
                  <SHORT-NAME>Fscsm</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="FEB3DD25-E499-4189-B5D5-03FD7952FBE3">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="A91DA0F4-23FE-4F73-8349-35A9BA7E02FE">
                  <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="9AABB83A-04E6-4299-B8FC-2C05436A5761">
                  <SHORT-NAME>NvM</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="0DBE4340-C4C7-4E4F-A063-996E000EE2FE">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="52EEC02F-ABC8-4165-937A-66ABEFEE8D50">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="96C86FFD-3E66-4CD0-9915-65461C46EC29">
          <SHORT-NAME>SystemDescription</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="6CCD646B-CDD4-46D0-88E2-C189DF847B62">
              <SHORT-NAME>BaseTypes</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="088C9FB8-35CB-46FB-A48E-98CE637BC585">
              <SHORT-NAME>CompuMethods</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="95A18FAB-A859-453A-8BBD-CFE1DF45CDFC">
              <SHORT-NAME>DataConstrs</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="15206304-0C04-4DC0-99F3-751BC7490229">
              <SHORT-NAME>Units</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="55873589-E0EE-403C-BE51-2DD3B5B55953">
      <SHORT-NAME>ComponentTypes</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="C6B49A8D-2381-44BA-B800-287FF63CED2E">
          <SHORT-NAME>ConstantMappingSets</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="724F61EC-1404-4369-BD78-CC7DF8F21376">
          <SHORT-NAME>DataTypeMappingSets</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="D696BFEA-50C5-45C2-B3CB-52579CDDB1D6">
      <SHORT-NAME>Constants</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="81921ABE-717A-4504-A384-5E28E8CC33F0">
      <SHORT-NAME>DataTypes</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="1C9DB839-D710-4DDD-81EB-082B473FFE7B">
          <SHORT-NAME>BaseTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="44D2635A-1873-4CA1-9257-B468B14BAD99">
          <SHORT-NAME>CompuMethods</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="E4994FC5-3606-4713-B47E-E9B2AD0242D7">
          <SHORT-NAME>DataConstrs</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="EFBC2479-D585-4F8F-8CFB-F408DDE17CA0">
          <SHORT-NAME>PlatformTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="7FBB2E0A-B5B0-454F-8C64-C01A7C23CD8B">
          <SHORT-NAME>Units</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="AB15681F-F7E2-4301-86FA-9019F9759B2C">
      <SHORT-NAME>ECUCompositions</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="4A623C62-0F7A-41FE-98EF-3877C757A0DE">
      <SHORT-NAME>ECUCompositionTypes</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="EAA1D10F-D085-42BF-A063-7A18FDB43B6A">
      <SHORT-NAME>EndToEndProtections</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="44838A5D-9B29-4EF1-8F51-1E0948E99F86">
      <SHORT-NAME>MICROSAR_SWCS_DEV</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="40CA23B5-26CC-4E27-AF06-EA27F6A31320">
          <SHORT-NAME>BswM_swc</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="70734986-61BE-4E10-A4CD-C8C7EA464712">
          <SHORT-NAME>Dem_swc</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="223448C2-FC8E-4AD8-80C1-A0191A8E6E65">
              <SHORT-NAME>DataTypes</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="906CD2C1-DEFE-4043-894D-D01BCE33251B">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="B4B17D7B-11BE-4EE1-B918-7D711C180811">
                  <SHORT-NAME>DataConstrs</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="6C2ECB11-484C-4834-987A-23838CF6F318">
          <SHORT-NAME>EcuM_swc</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="CDE7D7EA-27C4-43C6-BFCC-10477FAF4804">
              <SHORT-NAME>DataTypes</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="C467FC4B-0883-480A-981D-DF4BCDA25514">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="5716DF53-29E9-4693-BFB7-92AF71599D97">
                  <SHORT-NAME>DataConstrs</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="00A9D5D7-C06C-460C-81C9-8A873C17EDB1">
          <SHORT-NAME>NvM_swc</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="C68C8AB9-685A-42F6-A5ED-B33C78852C80">
              <SHORT-NAME>DataTypes</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="0F96BA9F-E3AB-4BA7-8053-94BE6BD0B7DA">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="42ECAAFD-D202-4BED-9016-96A63CC9B66C">
                  <SHORT-NAME>DataConstrs</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="CD4FF9B4-675C-49F0-9DD5-B8B0211E6478">
          <SHORT-NAME>Os_swc</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="8A35B032-AB9D-494E-BE3A-4C8A041D624A">
              <SHORT-NAME>DataTypes</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="CCCF2553-BDE5-4D19-ACEF-469C5B1E9FAA">
                  <SHORT-NAME>DataConstrs</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="066193EA-5BF7-4A1F-B46B-96DE7B9CFCE1">
          <SHORT-NAME>WdgM_swc</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="D211614E-E079-400F-839B-228A00A2CA8C">
              <SHORT-NAME>DataTypes</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="80985CE2-AEAA-452B-A3EA-7AC20E2745C4">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="A5E3F5A3-1856-434E-8918-3E532D9AB2DB">
                  <SHORT-NAME>DataConstrs</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="9EC97662-7F8F-4E3B-A38A-2B7B4475BF94">
      <SHORT-NAME>ModeDclrGroups</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="3832BF66-7657-42C7-B105-0AF01BD287B3">
      <SHORT-NAME>Nxtr</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="40FA8A58-D827-43FB-9CAA-6566A343F97B">
          <SHORT-NAME>Calibrations</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="B6EED526-EB9C-43E7-948E-327109E2467B">
          <SHORT-NAME>DataConstrs</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="A96F0713-E97F-4677-BDA9-B2836A0CF99E">
          <SHORT-NAME>DataTypeMappingSets</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="0140482B-98AA-4968-B65A-FB807A9285D7">
          <SHORT-NAME>DataTypes</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="172B6DD5-F18F-4595-BAB7-F2215C69DE97">
              <SHORT-NAME>BaseTypes</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="00FC3912-42F5-4FDB-B7EF-CC0FC623953A">
              <SHORT-NAME>CompuMethods</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="E93F6EFF-381F-456B-9B7F-EC0F9F7B7687">
          <SHORT-NAME>ModeDclrGroups</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="E604512B-2377-45E9-861F-6103F8EEE6AB">
          <SHORT-NAME>NvMProxy_swc</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="6B321737-FEB9-47DF-A7CA-24AE55766A83">
              <SHORT-NAME>DataTypes</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="67D9E37D-E7B3-47E2-9293-21E7F5D035B8">
                  <SHORT-NAME>BaseTypes</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="F130E0C8-6BD2-464D-8120-29DE7483C7A1">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="4C35ADD7-2FC0-4D25-882B-314DDDD84DED">
                  <SHORT-NAME>DataConstrs</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="2BB26679-94AF-490F-8CCF-25FE8795158B">
          <SHORT-NAME>PortInterfaces</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="F9105805-AE0F-4741-98DA-AC3309A91548">
          <SHORT-NAME>Units</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="7C93988E-0450-4FB4-A1EC-DABBE6247237">
      <SHORT-NAME>PortInterfaces</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="32516450-4B93-402F-8E6B-15927E681934">
      <SHORT-NAME>Predefined_DEV</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="0AB0355C-0CEB-4F74-B834-89EA8CF41EEB">
          <SHORT-NAME>CompuMethods</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="7A7BCC9A-35C9-4E51-80DF-D2EA00E124C5">
          <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="1C204E04-C1F1-4323-824D-EC34939081C4">
      <SHORT-NAME>Systems</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="B91F6085-A2CE-4B66-9947-E9D155CC0925">
          <SHORT-NAME>ModeDeclarationGroups</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="51E4D75B-2AE7-4E8F-BF61-5EFEE1590864">
              <SHORT-NAME>BasePartialNetworks</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="A6D79E34-020B-46BE-9E8D-262ED93E0FE7">
              <SHORT-NAME>FunctionalPartialNetworks</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
  </AR-PACKAGES>
</AUTOSAR>