<?xml version="1.0" encoding="utf-8"?>
<!--This file was saved with a tool from Vctr Informatik GmbH-->
<AUTOSAR xsi:schemaLocation="http://autosar.org/schema/r4.0 AUTOSAR_4-0-3.xsd" xmlns="http://autosar.org/schema/r4.0" xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance">
  <AR-PACKAGES>
    <AR-PACKAGE UUID="EA049788-5E14-4B39-A577-C4D3BEB7F403">
      <SHORT-NAME>AUTOSAR_Platform</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="1C6D6F63-1CEF-4917-BCE7-FBC8366E4628">
          <SHORT-NAME>BaseTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="88C271C1-8BF6-4CB1-A531-6CCF3317DC04">
          <SHORT-NAME>CompuMethods</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="070BF8B7-AEBD-4A24-8491-6A8C6D62324A">
          <SHORT-NAME>DataConstrs</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="C1E212B3-9E2B-4B10-AC48-8FA2F96DA634">
          <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="6B77E57D-2C9F-443A-ACAD-3AC681B04F41">
      <SHORT-NAME>Blueprints</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="5973249F-9076-474C-A3A4-C466F4376F37">
          <SHORT-NAME>BlueprintMappingSets</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="AFBBDEE0-0827-49D0-B354-F1E62CAADACF">
          <SHORT-NAME>PortPrototypeBlueprints</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="9DA67AEF-807B-4EC5-95C3-BB0B13274D12">
      <SHORT-NAME>BMW</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="11E75C04-EAA7-47A6-9568-0EE3EEE396E4">
          <SHORT-NAME>Boardnet</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="7C07BD8A-1EC6-4F3F-834D-A30AE4B3FCF6">
              <SHORT-NAME>CodingDatatypes</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="1A4132FF-FF5D-4E78-9B24-C6663EFB7A9E">
                  <SHORT-NAME>CompuMethodsForBoardnet</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="DC4CD29F-09C9-4B84-9374-DBF4D6683D04">
                  <SHORT-NAME>DataConstraints</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="C32A3C69-A5F6-42B6-9D74-4420079B3475">
                  <SHORT-NAME>SwBaseTypes</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="67AFFC9B-7BBC-4C75-B737-D0654278FDE5">
          <SHORT-NAME>Platform</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="A5189497-836E-4FCE-9EB3-8EED405E7C4E">
              <SHORT-NAME>Auth</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="8E5443E6-870E-4E42-839F-9FA16914F783">
                  <SHORT-NAME>Dcm</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="A99AC118-D6C8-4759-9E14-A4097498C94F">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="037E01C7-07FA-414F-AD44-A67F658500DC">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="6BF4FE02-53B1-41B3-889B-4CB6887213E9">
                  <SHORT-NAME>Dlog</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="D86015E1-4BA1-47BC-B6F9-BEF3588B20E8">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="27EBCE95-E777-41D3-8E3A-C40F2DFF0B50">
              <SHORT-NAME>Darh</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="376DF789-BB97-442B-8425-3553D3B25201">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="B9DB80B6-FFC1-4DAE-882D-18F7C3EF959B">
                  <SHORT-NAME>Dcm</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="CA7D917D-BF71-4C20-A8AD-992FB485C42B">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="A2BF2F0A-5458-40CC-AFE4-B72246C30CA1">
                      <SHORT-NAME>DataConstrs</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="6EBE999A-A05C-4EE6-AF16-3299F770FD3A">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="AE639249-BFE0-48DC-A822-5B1B5686AC74">
                  <SHORT-NAME>Dem</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="1BE3A1CE-E568-4641-B67A-CC3B994ADC37">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="C7A3022C-09C6-4036-BC0C-CDCAEFD66E43">
                      <SHORT-NAME>DataConstrs</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="92AA34AA-4D8D-4464-98B2-17C0560881F4">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="14915713-3917-434D-95F8-FC0F197B782C">
                  <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="1F141507-0654-4EE6-9F66-BD70E7C9C23F">
                  <SHORT-NAME>NvM</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="FF949326-94B9-4630-BCBE-45ED8444D877">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="5CF4816E-2963-418A-9C51-EF621F515207">
                      <SHORT-NAME>DataConstrs</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="8DA2537B-E29E-4474-ADD6-F6774E11E882">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="B1444566-17B2-425C-9362-5E7BD184CB38">
              <SHORT-NAME>Dlog</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="F8C30EB1-7967-44AB-A89A-03C551F64950">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="4B11C259-A3FF-4921-8B52-35025907B4FF">
                  <SHORT-NAME>Dcm</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="89DAFFB7-A18F-4333-A059-4670F918A42E">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="22C808EE-2CC3-4800-A6A4-C7941DB62BC9">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="58026EAE-9A17-4619-99E5-2B87B2DDA804">
                  <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="4A335F8D-C26E-4FDC-96B5-6A6B2E4BBBDE">
                  <SHORT-NAME>NvM</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="7F1C9154-E5D6-4F0D-8B91-0B595FDC0074">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="98C48E97-4FCD-447E-A76C-B222857A5885">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="BB69E0B0-643D-4DF4-9F72-26430945B12E">
              <SHORT-NAME>Omc</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="5FF986A1-D402-438D-B2C2-C4432B89A247">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="369941C4-3890-44CA-9C00-5265BE744DDC">
                  <SHORT-NAME>Dcm</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="704811BD-9CC5-4518-B99F-4D55AA300C7B">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="D2F61664-DA08-41C1-9CFB-987F9E9167CB">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="BC5160F9-A025-4DEF-877C-3977BEC2720E">
                  <SHORT-NAME>Dem</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="DB7FFCC0-7212-48D2-844E-758218FB2F67">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="42920F44-6A8F-45CB-AD22-8F9AD1C18217">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="DE34F13B-7DF8-4369-992B-EEF6B7BE86D5">
                  <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="97FDC165-BDFA-48E8-80C8-81B33011CF09">
                  <SHORT-NAME>NvM</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="198F0D4E-9D54-4EA9-8988-7DBBE708A5BB">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="AAAF1D60-4F46-4E89-8B90-552D4295C227">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="1E254599-A762-48FE-9A96-00107FB6267B">
              <SHORT-NAME>StdDiag</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="63C486BE-3D68-44F9-9B44-7D27E42744C4">
                  <SHORT-NAME>Coding</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="1B262040-5628-45C0-9ADA-82720EBC5799">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="00407F14-37DD-41F4-8D3B-B24DEDB92B6D">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="541F0271-4A23-4C56-8A5C-8ACEC941F6B0">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="D168EAB8-A12D-40AD-95C5-FB30422E26D5">
                  <SHORT-NAME>Dcm</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="05C0C81F-5E68-4B3A-A09F-D846DF199C60">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="5F8FB4B3-CC6E-4A8A-B4A5-BEB3D4818379">
                      <SHORT-NAME>DataConstrs</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="CEC90846-BD87-4ADA-B774-62C7B166963D">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="98443A81-CDDC-481E-A153-731CA2A3E164">
                  <SHORT-NAME>Dem</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="C0C782B1-4604-4ABF-872E-9AE5B35E5DF8">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="F3B53101-C811-45FD-8ADE-0E5764088B4A">
                      <SHORT-NAME>DataConstrs</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="F0A40ABA-BB77-4009-BAFC-6F9916749460">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="04ADE955-ABB9-4BC4-AD9C-9C2CC7661914">
                  <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="DAE671C0-9031-4046-8AF8-B15FD23DB28F">
                  <SHORT-NAME>Omc</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="434EFAE5-F2A3-4B96-B257-60B92919D2E7">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="1F4CB13A-36C6-40DE-8D8E-BF4F5ADF6C71">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="A6B9EDE5-C0D4-4A06-BDE7-CCFE9E28E0B5">
              <SHORT-NAME>Stm</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="4D966F36-245E-4623-B6F8-E72E9370F9A0">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="825412E2-4C36-4367-821B-2359A53C7B24">
                  <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="DB7B639A-B5BC-4E1D-AB53-312F2F4BF602">
              <SHORT-NAME>SysTime</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="6933F2E0-D042-43E6-886F-59B36F15FB76">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="6F208CD4-3460-46F8-AD2C-12E45E76A6E7">
                  <SHORT-NAME>Dcm</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="B17562EF-A35C-40C6-9B5E-D0961578F289">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="05E2E0C7-62EE-4614-9578-817DB076D781">
                  <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="8533A4C2-0D55-4574-86D1-DEC2761A7090">
              <SHORT-NAME>Vin</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="F54C2F4D-89EB-464A-9EF4-2BDE10C9FB46">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="CC488755-C273-4CEF-B592-CFE39EE0F35A">
                  <SHORT-NAME>Dem</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="2CE736BC-CDE3-4F8E-B011-3225C3825A9D">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="6049884F-F124-43FA-B657-2D4D696ACA98">
                      <SHORT-NAME>DataConstrs</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="09BDDE06-2882-4819-9D5F-E3B30473273F">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="196D58EB-480F-4070-83B2-03CB892D7133">
                  <SHORT-NAME>Dlog</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="48184AFF-0502-47E8-AEFB-239E847F4692">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="DAD6DDDE-3016-4285-9B54-EFCDC1E19D63">
                  <SHORT-NAME>Fscsm</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="8595EA5C-EA27-406A-8FE8-83AC3E89A3EC">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="379C1CBC-05F5-4D6A-86F6-9CAFAB819A01">
                  <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="806E4AC0-2D0A-48EE-8194-46294FCAC806">
                  <SHORT-NAME>NvM</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="C8A4F2D0-0618-465E-AB43-2F8D9BEE4932">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="0784E480-F4E2-4291-83C5-8FC2392B0D87">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="85EF9C94-FFDA-4233-BC39-CDF8E0D1A0AA">
          <SHORT-NAME>SystemDescription</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="396BE7B3-1BDE-4B7B-9821-2BDF1021A22B">
              <SHORT-NAME>BaseTypes</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="9FD2D099-DFD1-42C3-952F-D77DBE4C2FD0">
              <SHORT-NAME>CompuMethods</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="BFDF7DB7-4722-40AE-992D-07DBA11054D6">
              <SHORT-NAME>DataConstrs</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="2B6C2D96-1FE2-428A-90BA-628787897E7E">
              <SHORT-NAME>Units</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="55873589-E0EE-403C-BE51-2DD3B5B55953">
      <SHORT-NAME>ComponentTypes</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="C6B49A8D-2381-44BA-B800-287FF63CED2E">
          <SHORT-NAME>ConstantMappingSets</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="724F61EC-1404-4369-BD78-CC7DF8F21376">
          <SHORT-NAME>DataTypeMappingSets</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="D696BFEA-50C5-45C2-B3CB-52579CDDB1D6">
      <SHORT-NAME>Constants</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="81921ABE-717A-4504-A384-5E28E8CC33F0">
      <SHORT-NAME>DataTypes</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="1C9DB839-D710-4DDD-81EB-082B473FFE7B">
          <SHORT-NAME>BaseTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="44D2635A-1873-4CA1-9257-B468B14BAD99">
          <SHORT-NAME>CompuMethods</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="E4994FC5-3606-4713-B47E-E9B2AD0242D7">
          <SHORT-NAME>DataConstrs</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="EFBC2479-D585-4F8F-8CFB-F408DDE17CA0">
          <SHORT-NAME>PlatformTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="7FBB2E0A-B5B0-454F-8C64-C01A7C23CD8B">
          <SHORT-NAME>Units</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="AB15681F-F7E2-4301-86FA-9019F9759B2C">
      <SHORT-NAME>ECUCompositions</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="4A623C62-0F7A-41FE-98EF-3877C757A0DE">
      <SHORT-NAME>ECUCompositionTypes</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="EAA1D10F-D085-42BF-A063-7A18FDB43B6A">
      <SHORT-NAME>EndToEndProtections</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="E6840920-D616-4882-874F-679A1420728E">
      <SHORT-NAME>MICROSAR_SWCS_DEV</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="780BAD91-6DAD-4ADD-8C4B-D54D7A6970F2">
          <SHORT-NAME>BswM_swc</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="CB50A5A6-E40E-47B0-988E-2837BB52820E">
          <SHORT-NAME>Dem_swc</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="37A6ACBC-F539-4040-B0D3-FC44796378AB">
              <SHORT-NAME>DataTypes</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="91473C1A-A36D-4FD1-8541-AAEFFEE6CC04">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="1E2B6D6E-F5D2-4D10-A6D3-C3E668A5F638">
                  <SHORT-NAME>DataConstrs</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="22335718-4DAD-4C25-AF2F-EC2D53186406">
          <SHORT-NAME>EcuM_swc</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="A32CA564-86D1-4C4B-AABF-9C8C81CFC1FD">
              <SHORT-NAME>DataTypes</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="D61A2B9B-D031-44D0-93FB-847F6C10D3C2">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="F94B0B18-9268-46D0-BCF1-2971F0B20ADD">
                  <SHORT-NAME>DataConstrs</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="FE712F63-8947-4A0D-8077-F0D24C3C02F1">
          <SHORT-NAME>NvM_swc</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="FA489E3A-7733-44BD-A66B-503087303DC1">
              <SHORT-NAME>DataTypes</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="CD839E7A-4569-460E-8DC0-C07A0BE1810C">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="4D9A0D8F-6B36-4FFB-BE99-13479537F1EA">
                  <SHORT-NAME>DataConstrs</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="6EF991A1-DF94-4DF2-8ED5-25368781AC5D">
          <SHORT-NAME>Os_swc</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="5D1283DC-0D75-461C-ACB5-C9DBE6801F65">
              <SHORT-NAME>DataTypes</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="2F33F5AF-0849-4ECF-918B-5A035C48EE56">
                  <SHORT-NAME>DataConstrs</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="E92CFC74-6E1A-441B-969D-8C6EB3F4F449">
          <SHORT-NAME>WdgM_swc</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="0D1A5276-EA36-4F6A-957F-752F2F7213BC">
              <SHORT-NAME>DataTypes</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="F1736184-5169-4658-BBAB-78BAA163ACBF">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="68486B48-A9D3-4F4B-836D-BE6E5B014FDA">
                  <SHORT-NAME>DataConstrs</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="9EC97662-7F8F-4E3B-A38A-2B7B4475BF94">
      <SHORT-NAME>ModeDclrGroups</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="C767DD7E-404F-439C-AD95-B7C57A9AB15C">
      <SHORT-NAME>Nxtr</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="40FA8A58-D827-43FB-9CAA-6566A343F97B">
          <SHORT-NAME>Calibrations</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="B6EED526-EB9C-43E7-948E-327109E2467B">
          <SHORT-NAME>DataConstrs</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="A96F0713-E97F-4677-BDA9-B2836A0CF99E">
          <SHORT-NAME>DataTypeMappingSets</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="ED1FB228-B9B9-4381-9C23-282D72DFC177">
          <SHORT-NAME>DataTypes</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="172B6DD5-F18F-4595-BAB7-F2215C69DE97">
              <SHORT-NAME>BaseTypes</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="19681248-617A-4E26-89D4-806152CE82A2">
              <SHORT-NAME>CompuMethods</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="E93F6EFF-381F-456B-9B7F-EC0F9F7B7687">
          <SHORT-NAME>ModeDclrGroups</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="6DD72030-DA48-4304-8582-122BD9951C6F">
          <SHORT-NAME>NvMProxy_swc</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="06872796-4F9C-461A-8425-F0F981966D46">
              <SHORT-NAME>DataTypes</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="5FE9DC45-E589-4FA5-B5C6-BB70BB7C85FC">
                  <SHORT-NAME>BaseTypes</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="C7A48813-66C5-4ED7-9C9C-2C6F5D7023F3">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="70B21DC0-C67B-4864-9642-170A234AEB05">
                  <SHORT-NAME>DataConstrs</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="2BB26679-94AF-490F-8CCF-25FE8795158B">
          <SHORT-NAME>PortInterfaces</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="F9105805-AE0F-4741-98DA-AC3309A91548">
          <SHORT-NAME>Units</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="7C93988E-0450-4FB4-A1EC-DABBE6247237">
      <SHORT-NAME>PortInterfaces</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="0E99F4C2-5836-41E3-AA60-784132EB9FB4">
      <SHORT-NAME>Predefined_DEV</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="DABB1919-FDF1-4197-94CD-8A3B7FBD292E">
          <SHORT-NAME>CompuMethods</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="4A2B8136-17AA-45E7-B026-3D2B72C44E85">
          <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="1C204E04-C1F1-4323-824D-EC34939081C4">
      <SHORT-NAME>Systems</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="F411E165-5296-4657-9397-2DF6D7EBCB73">
          <SHORT-NAME>ModeDeclarationGroups</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="2B44D3C5-32C6-4AC4-A74A-9CB885703E02">
              <SHORT-NAME>BasePartialNetworks</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="6FE24B8C-0CF1-4222-AAFA-781A1DA3A264">
              <SHORT-NAME>FunctionalPartialNetworks</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
  </AR-PACKAGES>
</AUTOSAR>