<?xml version="1.0" encoding="utf-8"?>
<!--This file was saved with a tool from Vctr Informatik GmbH-->
<AUTOSAR xsi:schemaLocation="http://autosar.org/schema/r4.0 AUTOSAR_4-2-2.xsd" xmlns="http://autosar.org/schema/r4.0" xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance">
  <AR-PACKAGES>
    <AR-PACKAGE UUID="EA049788-5E14-4B39-A577-C4D3BEB7F403">
      <SHORT-NAME>AUTOSAR_Platform</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="1C6D6F63-1CEF-4917-BCE7-FBC8366E4628">
          <SHORT-NAME>BaseTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="88C271C1-8BF6-4CB1-A531-6CCF3317DC04">
          <SHORT-NAME>CompuMethods</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="070BF8B7-AEBD-4A24-8491-6A8C6D62324A">
          <SHORT-NAME>DataConstrs</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="C1E212B3-9E2B-4B10-AC48-8FA2F96DA634">
          <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="6B77E57D-2C9F-443A-ACAD-3AC681B04F41">
      <SHORT-NAME>Blueprints</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="5973249F-9076-474C-A3A4-C466F4376F37">
          <SHORT-NAME>BlueprintMappingSets</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="AFBBDEE0-0827-49D0-B354-F1E62CAADACF">
          <SHORT-NAME>PortPrototypeBlueprints</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="A954DE3D-D768-45D4-826E-F14A84EEBDD0">
      <SHORT-NAME>BMW</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="1596E290-9065-45E2-A326-B415F6FF8076">
          <SHORT-NAME>Boardnet</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="74552585-D33D-4A84-8A2D-A40933826EE4">
              <SHORT-NAME>Clusters</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="30DC05DE-75C3-49A5-AB58-C56BD42C0507">
                  <SHORT-NAME>CommunicationClusters</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="B980B59B-6411-4F03-BB6D-565B0D7A51C4">
              <SHORT-NAME>CodingDatatypes</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="35905AB4-E5DD-4D81-B4F6-F2395B4EEEF2">
                  <SHORT-NAME>CompuMethodsForBoardnet</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="C46247FB-FE2E-477F-9349-78A45574A041">
                  <SHORT-NAME>DataConstraints</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="EDA6D90C-8A0A-4342-8BE5-60EF8622C3B1">
                  <SHORT-NAME>SwBaseTypes</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="CBFEFA7F-40C9-4C2C-A92D-15B646BE0ABA">
              <SHORT-NAME>Ecus</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="74B04D8E-4914-44F2-BB42-BD8C819B3025">
                  <SHORT-NAME>EcuComposition</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="1CE2AACA-4962-49C1-9325-3133DF930277">
                      <SHORT-NAME>EPSComposition</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="E6DE4D67-0563-4DDE-A75C-DE7555271F5E">
                  <SHORT-NAME>EcuInstances</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="E977FA4D-B142-4AA2-B44E-3024A4133A00">
              <SHORT-NAME>Frames</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="B501B757-76D7-4592-A348-1F25EADDFA18">
                  <SHORT-NAME>Frames</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="F8292317-B6DB-49E8-BCCA-BC8C8B2AE912">
                      <SHORT-NAME>A_FlexRay</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="E364EA31-1DCF-42E1-B8D5-EF43EB920961">
              <SHORT-NAME>Pdus</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="951CBD86-56DB-4C33-A583-42C556DECB79">
                  <SHORT-NAME>ISignalGroups</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="757EE0D2-CCEB-40F3-9666-B6B831A82388">
                  <SHORT-NAME>ISignals</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="D30B6530-A1A9-49EA-9B2F-30D0E1261EB6">
                      <SHORT-NAME>A_TEMP</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="DA76E2A9-1632-4486-9525-5E4947928C42">
                      <SHORT-NAME>ACLNY_MASSCNTR</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="AD46E6F2-963D-480E-A558-3CE70340FB00">
                      <SHORT-NAME>ANFRAGE</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="6220BD23-F2CB-4709-A794-57C7E6B12CA0">
                      <SHORT-NAME>AVL_FORC_GRD</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="2FA1D16D-BBCD-4425-9E34-8444D5412C73">
                      <SHORT-NAME>AVL_PO_EPS</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="5999E0C5-4F4E-406C-B820-160AF927C573">
                      <SHORT-NAME>AVL_RPM_WHL</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="E9E35273-8F36-40D1-921E-ACA2541915A6">
                      <SHORT-NAME>AVL_STMOM_DV_ACT</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="209E7A6F-043A-4BAE-AF85-FE2DE0146519">
                      <SHORT-NAME>CON_VEH</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="79E9C0DD-00DA-45A5-B088-91428A5EFF64">
                      <SHORT-NAME>CTR_DIAG_OBD_DRDY</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="E8AF1C5B-2FE4-4458-90AC-E1867484D9E0">
                      <SHORT-NAME>CTR_VIB_STW_DISP_EXMI_SP2015</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="05D0403F-E855-4F76-A684-A8C792A4FF8C">
                      <SHORT-NAME>DBG_EPS_BS_MOD_58_BYTE</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="4988D434-787B-47E1-8800-B9F5ABD0F1DC">
                      <SHORT-NAME>DBG_EPS_MOD_EXT_120_BYTE</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="29B8706B-E332-4988-A7AE-A351086897BD">
                      <SHORT-NAME>DIAG_OBD_ENG</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="68A7A9CB-E5BB-4445-9A47-B4A26AC842F5">
                      <SHORT-NAME>DISP_CC_EPS</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="9173FA09-41CF-454E-B7DF-0793BECC7774">
                      <SHORT-NAME>DT_EST</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="510590FF-56D6-4A5E-BDD5-276AC5463F58">
                      <SHORT-NAME>ENERG_DGR_DRDY</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="5D8D2232-12F8-46D7-B492-3A9BD2DB01AB">
                      <SHORT-NAME>ENGTORQ_EPS</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="689A6B0B-F68A-4519-8C7D-FDB6234B5104">
                      <SHORT-NAME>ENSU_SFY</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="DF691862-53F2-4D29-B014-9EB67F91B399">
                      <SHORT-NAME>ERRM_BN_U</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="534147D8-D22A-4081-9B72-FFF6F5EE6D29">
                      <SHORT-NAME>FAHRGESTELLNUMMER</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="2F7FF8B7-0643-4F2A-912B-9D7DE32DAFAF">
                      <SHORT-NAME>FZZSTD</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="9CFC4DD6-89D6-4DD9-BB76-A550DE4A8E26">
                      <SHORT-NAME>KILOMETERSTAND</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="4E2FCC38-6BD8-4320-B9C3-8709C2186C71">
                      <SHORT-NAME>OFFS_QUAD_EPS</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="121F78D7-B397-4168-9C22-E2A63D719D9A">
                      <SHORT-NAME>RELATIVZEIT</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="08406FB6-3341-4871-A8A5-2155ACEC00E5">
                      <SHORT-NAME>RQ_STG_EFAN</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="51583EB7-4BB5-4A95-AFB9-8CEA7580A602">
                      <SHORT-NAME>SECU_CHAL</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="AA409B7E-8DFD-4841-AD6C-7FDE15A13DCE">
                      <SHORT-NAME>SECU_FAHRGESTELLNUMMER</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="BABB898D-3E08-40C2-B352-47046D948CBB">
                      <SHORT-NAME>SECU_RESP</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="7CB3E9A4-2D74-4841-8D7F-F28299B4EC98">
                      <SHORT-NAME>ST_CENG</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="EF6F250B-B92B-43C0-91D2-53B4A60E6581">
                      <SHORT-NAME>ST_DIAG_OBD_3_DRDY</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="10E185F8-0EBA-42E7-9098-ABDE951D667B">
                      <SHORT-NAME>ST_ENERG_GEN</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="A7BD15D2-8B86-4EB9-A853-4F29F71000E0">
                      <SHORT-NAME>ST_EST</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="A1E04A52-2434-4F4B-8E79-14C01563AECE">
                      <SHORT-NAME>ST_STAB_DSC</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="BF6DB9FE-AF12-43B6-9C37-A66489F29056">
                      <SHORT-NAME>STEA_OFFS</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="B55A48D9-FB60-4594-8330-C40587003414">
                      <SHORT-NAME>SU_CLE_DRDY_DXP</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="7DBFBE08-CB07-4A3D-91A2-83DD01AEB70E">
                      <SHORT-NAME>SU_EPS</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="BF54A7CE-D077-4113-A51F-3F94CE300BC3">
                      <SHORT-NAME>TAR_ESTP_VIRT_FTAX</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="9A0C8A7D-C84B-4CFD-98F6-93E53899C66B">
                      <SHORT-NAME>TAR_QTA_STRMOM_DV</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="593580C0-5AD3-4F04-9484-B26A0044DD9E">
                      <SHORT-NAME>TAR_STMOM_DV_ACT</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="AE3A6B5D-84B2-45A9-B58A-59660B81D826">
                      <SHORT-NAME>V_VEH</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="E76D28C4-0591-4B9D-AAE4-BC9D00D6463D">
                      <SHORT-NAME>VYAW_VEH</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="E847F578-7647-471F-85A0-A4CE4A9809C3">
                  <SHORT-NAME>PDUs</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="4C4F14E4-91C4-4DD7-B87C-83C346E7DC27">
                  <SHORT-NAME>SystemSignalGroups</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="E344A5BF-825F-4DEE-A323-E189F792D7D1">
                  <SHORT-NAME>SystemSignals</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="E3D0EF96-2850-40D0-A96F-51CFA62BB19A">
                      <SHORT-NAME>ANFRAGE</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="AFF091DB-ABB5-4630-8D3F-D547580FC8D8">
                      <SHORT-NAME>DBG_EPS_BS_MOD_58_BYTE</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="56B6349A-E3B9-40C0-8771-FED45B27A65E">
                      <SHORT-NAME>DBG_EPS_MOD_EXT_120_BYTE</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="3EECC029-B3F1-43E6-A77E-D68911747830">
                      <SHORT-NAME>RQ_STG_EFAN</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="B223EDC9-1ECA-448B-9A92-FF5943D27013">
                      <SHORT-NAME>SECU_CHAL</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="DA9CBC20-4B89-4912-BBA1-9DB64EE27484">
                      <SHORT-NAME>SECU_RESP</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="071D234B-A4B1-4BA9-A374-F29B463AD903">
              <SHORT-NAME>Signals</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="42506565-7A25-4CD0-B3C7-8CEA7C42AA39">
                  <SHORT-NAME>SystemSignals</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="6CB35E9D-3687-49F0-980B-7C66BA3FF061">
          <SHORT-NAME>Diagnostics</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="28CBB85F-7674-4EA9-AB79-2B03C7D832A5">
              <SHORT-NAME>ComponentsWithoutQualifiedName</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="0C255D57-2910-42B9-8D7E-F4979F704654">
                  <SHORT-NAME>DiagnosticAccessPermissions</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="DF190E8F-88AF-45AC-911E-B854CFF32C2C">
                  <SHORT-NAME>DiagnosticDataIdentifiers</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="AD698B22-54C5-42C9-B191-D2AF6633B9CD">
                  <SHORT-NAME>DiagnosticServiceInstances</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="0DB12EF2-E90F-4386-BC91-9DD36640B73D">
              <SHORT-NAME>Ecus</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="31BCA29B-03CB-4F41-8831-A4168067C299">
                  <SHORT-NAME>DiagnosticAccessPermissions</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="9460BEE4-2D64-4904-81AA-FDBBAECC03AA">
                  <SHORT-NAME>DiagnosticContributionSets</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="727E8EA4-939A-44E6-B996-ABAA8CA46306">
                  <SHORT-NAME>DiagnosticEcuInstancePropss</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="D05E62F5-8493-45C2-95A0-4C233C86EF70">
                  <SHORT-NAME>DiagnosticExtendedDataRecords</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="B7D151FE-9F6E-4037-9CBC-668EBE1E3A5E">
                  <SHORT-NAME>DiagnosticMemoryDestinations</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="53983ED7-F6B1-4DF1-AFC3-3B253BEED25D">
                  <SHORT-NAME>DiagnosticProtocols</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="BFACB8A3-E69F-4417-A8B1-9DC9B4868D8C">
                  <SHORT-NAME>DiagnosticServiceClasses</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="1D46A1C1-8ACD-4ECB-A91C-FCED121AFE48">
                  <SHORT-NAME>DiagnosticServiceInstances</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="1B3A2BBF-5F4A-4A78-9F18-05A12CCA1628">
                  <SHORT-NAME>DiagnosticServiceTables</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="3E1252D8-6237-42B3-AF35-BD57AE6CC2D6">
              <SHORT-NAME>Sessions</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="4F0A182D-76F8-4C7B-B0FB-F367F1570C35">
                  <SHORT-NAME>Application</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="FCE5CFC6-7757-454D-9C88-721CD96CBDA3">
              <SHORT-NAME>TroubleCodes</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="E7C57767-5BC8-4330-B914-5CB5D2379657">
                  <SHORT-NAME>DiagnosticTroubleCodeProps</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="31BB6401-4C2F-4277-BFB1-484ECE8A4DE4">
                  <SHORT-NAME>DiagnosticTroubleCodes</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="CA700395-AA47-40E3-8750-3AE48B2D8FF1">
              <SHORT-NAME>UnmappedZedisContent</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="A84528AA-0FB6-4BB1-85EF-7DC60AFBE9AD">
                  <SHORT-NAME>DiagnosticAccessPermissions</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="1E7CB44E-DA80-4A71-85BE-E7AE18769E84">
                  <SHORT-NAME>DiagnosticDataIdentifiers</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="2D777FA3-9522-4FF8-BC74-CBB49D11BAF9">
                  <SHORT-NAME>DiagnosticEvents</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="BF645593-ECAB-4809-AE32-BDF7B46F270B">
                  <SHORT-NAME>DiagnosticFreezeFrames</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="FAE3BE9D-B47D-4654-BA62-39704A26FC20">
                  <SHORT-NAME>DiagnosticMappings</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="9993BF51-25DD-427F-B4E6-8BD669B717C4">
                  <SHORT-NAME>DiagnosticRoutines</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="3BC66C39-6370-4283-9EDC-059192339B64">
                  <SHORT-NAME>DiagnosticServiceInstances</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="0BE41B1E-740C-4119-A46C-261F653F272B">
          <SHORT-NAME>Platform</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="49358E65-3816-4A24-B53A-3EC8BBD0B30B">
              <SHORT-NAME>Auth</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="F767DF0B-9F22-426B-8C4C-3EB6875E1E9A">
                  <SHORT-NAME>Dcm</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="B8AA1430-F497-4888-B294-CBECDE7FA5B2">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="3F91A85D-E9D2-496E-AE9A-02B883236FD3">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="9214A5CB-2D12-46F8-8FED-C854185A7D01">
                      <SHORT-NAME>PortInterfaces</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="39014353-CD05-4BE7-98F1-F169098C833D">
                  <SHORT-NAME>Dlog</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="A4C3F9CB-0E3C-4DEC-8026-E99FD8AF4905">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="A5D2BA40-7872-4A9E-A0C5-553520D235A9">
                      <SHORT-NAME>PortInterfaces</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="D31E1571-3483-4B68-AF65-E786A50A66B1">
                  <SHORT-NAME>PortInterfaces</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="799F202A-D184-41A6-A75A-02CA2F6DDE0C">
                  <SHORT-NAME>SwcImplementations</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="CAB6F06D-B0FD-4350-8A32-232A3DB44F63">
                  <SHORT-NAME>SwComponentTypes</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="9C151D84-9D33-4DCA-BE67-505DBAA75BDE">
              <SHORT-NAME>Coding</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="9924B600-62D5-4109-B2D5-2525FDCA1D19">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="0E26376C-0917-4CF9-9B7A-A32790249D55">
                  <SHORT-NAME>DataTypeMappingSets</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="0A424255-2099-49AC-A77C-CFDC43AC6397">
                  <SHORT-NAME>Dcm</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="415FAF1C-3CAE-4482-8097-8AC49377433B">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="298DF35D-F79C-43B2-BEB6-15E3A77E9E04">
                      <SHORT-NAME>DataConstrs</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="59A3B210-F556-454C-ACAA-A54D1121097E">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="80FF2739-394A-445A-9A44-3A6B010F7BEF">
                      <SHORT-NAME>PortInterfaces</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="B90AD633-A31A-4B33-A779-08C360055397">
                  <SHORT-NAME>Dem</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="C80C096C-B1EF-49CB-9A5B-6A386384834D">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="2766D7DC-A1E9-41BF-9F7C-98B3864A7121">
                      <SHORT-NAME>DataConstrs</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="F845C30E-55CB-4C09-8EA4-31BFDBDFB443">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="4C945ED4-4184-4EB1-8789-EFD0E180296F">
                      <SHORT-NAME>PortInterfaces</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="F18868E5-625B-4BB1-AA01-D3B592E9AB2C">
                  <SHORT-NAME>Dlog</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="B766835C-284B-4843-A786-F0C978E71E4A">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="E1EFD215-CB55-44EE-BE6E-836DA26A6AF0">
                      <SHORT-NAME>PortInterfaces</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="F807AE10-F4E8-48C0-B988-A70A58E09879">
                  <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="417E0AAC-3752-4C38-ABB5-B0D22BD6C955">
                  <SHORT-NAME>ModeDeclarationGroups</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="8520EA80-FCE7-4037-AA57-081C82CBA008">
                  <SHORT-NAME>NvM</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="51A206DD-4F44-4727-96E0-D14103BBF6F7">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="95FC4F26-267E-48F2-A525-44FD4FC14DF0">
                      <SHORT-NAME>DataConstrs</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="F2CF77CF-4DC1-4383-B921-20BF59E46456">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="62BF0230-3E52-4453-AA80-1D016F36849B">
                      <SHORT-NAME>PortInterfaces</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="3C34D186-D999-47F2-B0F8-4E7D3B6C57C5">
                  <SHORT-NAME>PortInterfaces</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="B99B93EC-93E2-43A3-9DF8-81275B866A13">
                  <SHORT-NAME>SwcImplementations</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="0887DD55-757B-4018-9E1C-B93EAC034DC6">
                  <SHORT-NAME>SwComponentTypes</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="9E237C2B-C7FA-4706-AEFA-D26D749CF415">
                      <SHORT-NAME>DiagnosticAccessPermissions</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="D793E75C-02C2-4A4B-AE57-DE5AC7459F4D">
                      <SHORT-NAME>DiagnosticDataIdentifiers</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="196F348D-3E16-40BA-8016-DB347758300A">
                      <SHORT-NAME>DiagnosticEvents</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="84E64EC1-DB63-483D-8B6C-CD563468357A">
                      <SHORT-NAME>DiagnosticMappings</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="1178EFF5-CA29-46D4-BD2C-1C37899160DD">
                      <SHORT-NAME>DiagnosticServiceInstances</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="B47D5F8C-0E50-43C8-B9CE-33FBF63821F7">
                  <SHORT-NAME>Vin</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="1CA7A9FB-53AF-4B28-AAF5-07675FE70E07">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="865EAC05-C776-4593-983B-F09ABB8BE8A3">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="1EDDEFB1-A6F9-4275-A744-A494A688B30F">
                      <SHORT-NAME>PortInterfaces</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="A8F59375-DCC7-42F5-AA9E-29FB003B9087">
              <SHORT-NAME>Darh</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="309553C8-EB3E-4F32-AD79-AC1E07D9039A">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="6F5F38F5-8272-46ED-B69D-D28CDFEA453D">
                  <SHORT-NAME>DataTypeMappingSets</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="1D3C6467-0BBB-40CC-B1C3-3076C4EDB7B5">
                  <SHORT-NAME>Dcm</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="99EF8B96-2BC8-46E4-BABD-5BAD4BD10A38">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="A2C0F000-9330-4B19-8A0F-57C28500B1A0">
                      <SHORT-NAME>DataConstrs</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="AC64FA73-5D35-4AA1-B11C-6BFC7E4C26DA">
                      <SHORT-NAME>DataTypeMappingSets</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="C9681D90-B001-4FD2-9F52-12291DA73F44">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="EAEDB751-8CDF-43DC-BC1D-95199A46A310">
                      <SHORT-NAME>ModeDeclarationGroups</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="E15D994B-DA69-4920-BEB9-67596BDCB6E2">
                      <SHORT-NAME>PortInterfaces</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="CF567392-1F41-480B-9F76-383727988B2C">
                  <SHORT-NAME>Dem</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="50BC81D2-711B-48E1-A350-79D03B58BC75">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="C2795C05-02DF-4008-9269-78A5C3CBB622">
                      <SHORT-NAME>DataConstrs</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="ACFF881B-A25E-453B-9355-B4AAF6E3D4F5">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="04850100-E79E-4357-86CC-17A6DD2AB70D">
                      <SHORT-NAME>PortInterfaces</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="92EC07AD-852F-4C2B-82C5-0526FD911698">
                  <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="C37F1A79-66CE-4164-9229-8175BCDF7CE7">
                  <SHORT-NAME>ModeDeclarationGroups</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="CBD761F1-D31C-48EC-AC23-98ADC7AFA5C7">
                  <SHORT-NAME>NvM</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="87349927-A6D9-460B-A047-B15B8C3FDBE1">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="61EEFBEF-1FD6-41D9-A532-1F69778C3299">
                      <SHORT-NAME>DataConstrs</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="ECD2447F-EF88-4FB2-8F99-986A74E0FE31">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="B221BF55-2C3C-4C26-9ADF-65BE49C8BDD2">
                      <SHORT-NAME>PortInterfaces</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="506FC36F-7247-4F31-B420-AC257E9D74F7">
                  <SHORT-NAME>PortInterfaces</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="921BA396-6147-4C76-A4C9-350D3F0C256B">
                  <SHORT-NAME>SwcImplementations</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="29F17945-973C-47EE-B228-1AE5CC8D40D2">
                  <SHORT-NAME>SwComponentTypes</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="3CF6B7B1-0BBA-4FCE-AE14-1ED2990B578F">
                      <SHORT-NAME>DiagnosticAccessPermissions</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="D0918B89-F0A9-4107-BA72-1D62317D7FCF">
                      <SHORT-NAME>DiagnosticDataIdentifiers</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="A5986571-00D0-47B3-9CA2-B06FB558EF0A">
                      <SHORT-NAME>DiagnosticEvents</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="4ABF8AD5-0E2B-4396-8A75-962809628225">
                      <SHORT-NAME>DiagnosticMappings</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="AF382B27-1030-4F3C-8866-645445E4B90C">
                      <SHORT-NAME>DiagnosticRoutines</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="6FD1CD8E-5BEA-40C2-A7C3-B5FDADCB7BBE">
                      <SHORT-NAME>DiagnosticServiceInstances</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="69278A35-C075-4158-9EA1-C8C0C39FC247">
                  <SHORT-NAME>Tp</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="6F1F9E35-5281-4759-817A-A957E9AFE31B">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="C1CF8491-19A3-4561-B87C-D07252B6B1FB">
                      <SHORT-NAME>PortInterfaces</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="3005C15A-D1D0-491B-B6CB-B97D361474A9">
              <SHORT-NAME>Dlog</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="60FAB8F5-A4A6-4FE7-84D9-57F825B86395">
                  <SHORT-NAME>Coding</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="04B54D2F-D11A-48AA-9AC5-240CED783EAE">
                      <SHORT-NAME>PortInterfaces</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="425090E5-BC25-4CF6-917F-16C4AC8D0E64">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="0CE49CB3-7509-4BF9-A0A8-C6C71C793EDA">
                  <SHORT-NAME>DataTypeMappingSets</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="7EA3FEB5-CEFD-47D1-9CDD-DED133857707">
                  <SHORT-NAME>Dcm</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="90683FD9-E5C2-47A1-B460-550C0A909A78">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="D9FA46CC-710C-4FFA-A1BD-8AEBF55CD111">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="72DBC0E6-0BE3-4EBD-A801-C42C9CEEBA80">
                      <SHORT-NAME>PortInterfaces</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="F5958F3C-5136-447A-8240-2841A92369BE">
                  <SHORT-NAME>Det</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="CEE12171-151B-48F0-AE6E-76B1D8D7DCC0">
                      <SHORT-NAME>PortInterfaces</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="8F373783-E3F2-4746-98B2-C8DC7566B15B">
                  <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="6438D509-9A81-4811-8DB9-3DC01B7A5B3C">
                  <SHORT-NAME>ModeDeclarationGroups</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="BB6BCAC8-4FD3-471B-B3AE-157AE11D6F29">
                  <SHORT-NAME>NvM</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="A6602221-3A8E-4847-BFB7-761A91ECDB6A">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="23D4412C-26AF-41FF-A265-2D64D98A693C">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="05B6BC32-1413-4A75-BE2E-0929B0618F3A">
                      <SHORT-NAME>PortInterfaces</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="99D78A3A-BED3-47FA-9570-7C2DAE29AAA2">
                  <SHORT-NAME>PortInterfaces</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="9A305D62-2A89-4FBC-BB2A-6254A516DEA3">
                  <SHORT-NAME>SwcImplementations</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="E64950CC-64B5-4855-B05C-430E19EFCDC9">
                  <SHORT-NAME>SwComponentTypes</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="D66E0C9C-AEF2-4C2A-A846-BD7C705F94C8">
                      <SHORT-NAME>DiagnosticAccessPermissions</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="81F1B721-15E2-462B-B92A-8CE475689A25">
                      <SHORT-NAME>DiagnosticDataIdentifiers</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="6DCB2BEF-3C2B-48AB-B05C-28A80681C8F1">
                      <SHORT-NAME>DiagnosticRoutines</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="F56E4579-6B61-45CB-806A-18017E6154DD">
                      <SHORT-NAME>DiagnosticServiceInstances</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="2D651D4D-930B-44BB-B7CE-C03B976B5E7B">
              <SHORT-NAME>Omc</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="287FD09C-2804-48CF-9803-F224FB806015">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="8EE8A8B7-1658-4558-874E-51247D34407D">
                  <SHORT-NAME>DataTypeMappingSets</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="22B8DE9C-60A7-4103-A942-0CFE37BA9467">
                  <SHORT-NAME>Dcm</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="8C1FA299-658C-498C-B86D-AA131E734566">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="9CC0C0E1-6034-4AE4-933D-164E31925FE3">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="F9D738BF-B41E-4583-B36F-6873F0631CB7">
                      <SHORT-NAME>PortInterfaces</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="3F888C4C-0481-4121-AA59-D51A590F88CC">
                  <SHORT-NAME>Dem</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="3DAFDB41-78EB-40FD-AC73-9F878224729D">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="9D1FCFC4-447E-49F4-B7AD-C2EA1717321B">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="8C25D284-CCF0-4F2F-9B4C-4D213DE04222">
                      <SHORT-NAME>PortInterfaces</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="869665F7-AB83-4BCA-9486-CD2C9A80E8DB">
                  <SHORT-NAME>Det</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="D564DA85-34D1-4E0A-B9A7-CF131A27EC57">
                      <SHORT-NAME>PortInterfaces</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="E3F834FA-10FB-4384-9314-DF98FC6DB85D">
                  <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="A9EEB593-B0ED-4F2C-A3CF-B08584AB8F34">
                  <SHORT-NAME>ModeDeclarationGroups</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="F2B59884-D5E5-4B7D-B248-407C3CB9A4A4">
                  <SHORT-NAME>NvM</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="CFCE6A32-A58E-4102-A39C-31F514B9C6E3">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="CA411199-991A-4737-B2D6-6421EDA5E1E8">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="51377074-1216-4344-ACE9-7EADC07A387C">
                      <SHORT-NAME>PortInterfaces</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="FBB71A25-72B2-486F-9051-27D3B283AF7F">
                  <SHORT-NAME>PortInterfaces</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="EFECF347-30CF-413C-A329-1C2367343DCF">
                  <SHORT-NAME>SwcImplementations</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="28FDA640-C43A-4E4E-A6F2-2E1B21E6B192">
                  <SHORT-NAME>SwComponentTypes</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="4CB8B1CD-C2C1-4C4A-8352-1418E252CF66">
                      <SHORT-NAME>DiagnosticAccessPermissions</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="83A1FC09-D7D7-4D2F-BDD9-BFDF46E744AB">
                      <SHORT-NAME>DiagnosticDataIdentifiers</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="BA26C8CB-B689-436D-B5B8-2E91C2DF670A">
                      <SHORT-NAME>DiagnosticEvents</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="780A9C81-8F32-45D8-A347-7382829BAC14">
                      <SHORT-NAME>DiagnosticMappings</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="7E34474C-986F-4D34-AF57-5DD09DFE39F4">
                      <SHORT-NAME>DiagnosticRoutines</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="F77DB347-9273-4A17-B052-CF5305B4C37E">
                      <SHORT-NAME>DiagnosticServiceInstances</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="48A00E0E-0048-43D4-9439-DCC9FF8C2F48">
              <SHORT-NAME>Prog</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="AFA7212B-D8A0-421E-A4F3-169DA1E7C735">
                  <SHORT-NAME>SwComponentTypes</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="4C6A5D58-ED29-47DC-B4BF-79422D92DDE0">
                      <SHORT-NAME>DiagnosticAccessPermissions</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="B0F9C141-1C43-41D3-982F-D76FB7D658B5">
                      <SHORT-NAME>DiagnosticRoutines</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="9BC00584-2D48-47C8-9AA9-B5AEDE5F8700">
                      <SHORT-NAME>DiagnosticServiceInstances</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="4E7F7C80-60CE-47A9-B726-F40A8174C7A8">
              <SHORT-NAME>Rmh</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="B760C7E0-49E4-4FBF-A910-D912B3C17C7D">
                  <SHORT-NAME>PortInterfaces</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="1B9A135E-2E3D-4361-A1A2-E24744E242DC">
                  <SHORT-NAME>SwcImplementations</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="689677E4-7587-4E43-883E-0543875676BE">
                  <SHORT-NAME>SwComponentTypes</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="A59D0727-BE6A-49DB-94EE-93F20D33F8D5">
              <SHORT-NAME>StdDiag</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="02F66BCF-D9F1-40C9-826E-9B688F0B928A">
                  <SHORT-NAME>Coding</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="85FC206E-BE94-4DA3-AD12-AE89BF77B684">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="0BDE6481-67FB-41DA-B5D8-874F7F4C4798">
                      <SHORT-NAME>DataTypeMappingSets</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="AF005441-F001-4DD9-AD1C-0229489CF646">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="F495A327-F612-409E-A659-1FD77BA39652">
                      <SHORT-NAME>ModeDeclarationGroups</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="FD52EC7A-1A2B-4CA4-8D45-51B5E40663E4">
                      <SHORT-NAME>PortInterfaces</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="292ACE04-12E4-4813-A000-AB85FDBCA4D3">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="66345D5A-7C96-4469-AE58-6AFB1BD81874">
                  <SHORT-NAME>Darh</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="F427FAA6-D8C4-4A4B-B683-B683F8BB828E">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="343B7276-618A-478A-9C34-08006D478821">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="5EBCB2C1-0A84-4660-81C3-53EBAD0FC0E3">
                      <SHORT-NAME>PortInterfaces</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="79CFCC0F-EC77-4195-B7F8-F6EE74AABB89">
                  <SHORT-NAME>DataTypeMappingSets</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="0147F8E9-9A72-46B8-A347-F808BDCE27D3">
                  <SHORT-NAME>Dcm</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="449E7BF2-6CA4-4141-BD4D-E1D74B6C4680">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="2A8CB07E-9462-4155-92C7-2CB996F59408">
                      <SHORT-NAME>DataConstrs</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="6EDA54DA-691E-4ED8-AEA5-7D870C2EEC71">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="41E249AB-8DDC-4205-97AB-19523FE8B833">
                      <SHORT-NAME>PortInterfaces</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="15F5C7ED-1AC2-44D7-ADD7-6C35830A7131">
                  <SHORT-NAME>Dem</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="5252089C-9A5E-494E-B909-A99F8C1BD576">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="671E9617-872D-4E0B-96D7-B429426310B9">
                      <SHORT-NAME>DataConstrs</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="16A6FCCF-8297-4767-804E-EA635981AE94">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="EE1776CC-AABF-45DC-B1A9-C71061326C56">
                      <SHORT-NAME>PortInterfaces</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="65D3D562-664A-4474-A06E-47EA69663E1E">
                  <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="6867DBBB-E4ED-4777-AA3E-7F634A54B12E">
                  <SHORT-NAME>ModeDeclarationGroups</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="0F29A111-C3A8-4794-97F3-C3109DE108D4">
                  <SHORT-NAME>Omc</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="3414CF65-D03F-470E-B8D0-FADF18A5156B">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="0DFB3022-1768-4F52-BC0C-AC97DE637F14">
                      <SHORT-NAME>DataTypeMappingSets</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="6184EE34-73D0-447E-A8F4-37AF4784ADA9">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="5ED1BA9C-417E-4319-9F7D-218A8179317C">
                      <SHORT-NAME>ModeDeclarationGroups</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="7E0B24AC-4AAD-4687-98F4-84C253FEB771">
                      <SHORT-NAME>PortInterfaces</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="725F8F81-EDCC-4BEE-8A24-52BA83837212">
                  <SHORT-NAME>PortInterfaces</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="EB5E9352-30B8-46D9-9D3A-382B37D09B47">
                  <SHORT-NAME>Stm</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="C5C17651-9825-4819-83FB-12F0B20EBBE1">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="403EF175-E3D1-4538-8273-F05710D46AE1">
                      <SHORT-NAME>DataTypeMappingSets</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="C0A9DBF6-C9FD-42D1-8201-EE6307C6D957">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="B9023293-6BE8-408B-8F1E-54F90DEDE52A">
                      <SHORT-NAME>ModeDeclarationGroups</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="1306D116-5A99-4C0F-9D1C-CA9EC2B28B53">
                      <SHORT-NAME>PortInterfaces</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="44D6F0AC-754D-432B-BCD0-A1FA7D087DC2">
                  <SHORT-NAME>SwcImplementations</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="6ED0B6C9-80B8-4A5C-983C-8AC396E95674">
                  <SHORT-NAME>SwComponentTypes</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="BAAFB6F1-D20F-47FE-B558-90B15AAE949E">
                      <SHORT-NAME>DiagnosticAccessPermissions</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="5FDDE997-9CE0-48DF-A4A7-703DC0991510">
                      <SHORT-NAME>DiagnosticDataIdentifiers</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="744AA3E2-0E90-4663-8D8E-71C2C8A47DD0">
                      <SHORT-NAME>DiagnosticRoutines</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="58FE01A2-99FA-447D-957B-8A4D8F991F33">
                      <SHORT-NAME>DiagnosticServiceInstances</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="DF475ECD-F06E-4397-B068-9B512CF717FF">
              <SHORT-NAME>Stm</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="01055900-23CE-466A-8507-9FDEEFEF9CE9">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="4FB6CE8D-3402-4CF9-B685-4C0224446570">
                  <SHORT-NAME>DataTypeMappingSets</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="921ABB11-E73E-40C4-9863-38E783A5AB5B">
                  <SHORT-NAME>Dem</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="A2869D95-6A65-44B5-856B-99CA4E3B2009">
                      <SHORT-NAME>PortInterfaces</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="FB3EF381-EA40-4C33-A000-674903ACECA3">
                  <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="9C77DD49-93A4-4E1F-BBB4-2240175AEE7C">
                  <SHORT-NAME>ModeDeclarationGroups</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="4B73A81C-1DE4-411F-BD3F-240E04ACE99C">
                  <SHORT-NAME>PortInterfaces</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="7174F4CC-FCD9-4EB8-9D00-C066CA066406">
                  <SHORT-NAME>SwcImplementations</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="93BECF4C-C321-455F-A925-9C7447D09C29">
                  <SHORT-NAME>SwComponentTypes</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="D763C8AF-4094-4836-99FD-EBF67E4E0C96">
              <SHORT-NAME>SysTime</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="2806AA91-D759-4BE9-A727-47788B690141">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="962772D7-3710-4E44-8CD7-07FA702491F0">
                  <SHORT-NAME>DataTypeMappingSets</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="878E5D83-4A14-40D2-8E73-A752A7B5840A">
                  <SHORT-NAME>Dcm</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="23113624-0E4A-4449-9A41-B8CE094D70E7">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="AABC3BD9-7E3F-4CB4-9C0C-38541C2014BE">
                      <SHORT-NAME>PortInterfaces</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="12E36F28-67F2-43FD-BEE5-3A5B7F625366">
                  <SHORT-NAME>Det</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="E8B42232-CA01-4B5A-9AF5-EA71A0A0DD4E">
                      <SHORT-NAME>PortInterfaces</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="3589201B-5411-4A8C-9130-B0A08B49667A">
                  <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="A95A0EAE-D674-4FB6-BF1A-1947509B8EF3">
                  <SHORT-NAME>ModeDeclarationGroups</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="058B7463-7C49-47DC-ABA6-2A437F8AE174">
                  <SHORT-NAME>PortInterfaces</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="3A9BCEAA-6D25-43EF-8977-81509AEE9D99">
                  <SHORT-NAME>SwcImplementations</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="287AC592-CFCB-4903-87C7-8A59C275572A">
                  <SHORT-NAME>SwComponentTypes</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="824A54D1-3757-4B86-BC02-CE560F8959B4">
                      <SHORT-NAME>DiagnosticAccessPermissions</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="D5F26E24-A677-4DBC-9DA4-339F7064CDAD">
                      <SHORT-NAME>DiagnosticDataIdentifiers</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="09F003CD-C722-44A6-8142-14B7E01112BD">
                      <SHORT-NAME>DiagnosticServiceInstances</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="FC2CE548-8B10-48F5-BF22-864C32C3EF16">
              <SHORT-NAME>Vin</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="737E02AA-46B7-4A35-9A73-14529F832259">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="F01B6982-94F6-47F4-9015-4FC805542801">
                  <SHORT-NAME>DataTypeMappingSets</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="924DC085-CD03-4DF3-8F7D-0C964B8F30D7">
                  <SHORT-NAME>Dem</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="489FD4CF-1E41-4612-B0F9-180ED75AAD35">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="282E7AFC-964E-45C1-B3F5-FC707CF932AC">
                      <SHORT-NAME>DataConstrs</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="B071CEBF-4836-40E9-8BDC-648346A04071">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="46EB6CF4-0524-4AD6-9AF2-1AA8C78C695A">
                      <SHORT-NAME>PortInterfaces</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="32007737-0920-4798-9BAD-4FDF53B8311A">
                  <SHORT-NAME>Det</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="B70D3012-0252-4B92-9776-829E9D97BC8F">
                      <SHORT-NAME>PortInterfaces</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="17CF470B-7118-4DBA-895D-510BB15D3035">
                  <SHORT-NAME>Dlog</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="8FDAF9BF-A1FB-4C63-9F80-4083079A35D7">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="92392A1B-33E6-4452-8504-9A52033ECC0C">
                      <SHORT-NAME>PortInterfaces</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="CF284693-4564-4E9A-B0BE-F0555D236293">
                  <SHORT-NAME>Fscsm</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="B8FC6399-6F4A-4549-8608-2BEA64EDCF9F">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="3B4A2AF6-1DE3-4D0E-A85A-17A10FCF0D84">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="F33C226F-A73D-4E2A-8919-E3FE71935326">
                      <SHORT-NAME>PortInterfaces</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="A4B39CAA-70AB-43F5-AD90-13269947ECE0">
                  <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="10108EFE-3AD0-4451-BB0C-BF42CDE05940">
                  <SHORT-NAME>ModeDeclarationGroups</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="1B872C5B-CB13-46C8-8743-8B47CE90993F">
                  <SHORT-NAME>NvM</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="C7657DDE-C2ED-4910-B36E-B65B42A83A83">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="56330022-B2E1-4D77-9119-A9AAB6E39592">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="E545C298-ADCB-44B5-812E-85B43EB14B9A">
                      <SHORT-NAME>PortInterfaces</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="7470756A-361F-4DF5-833B-B339FBDC6FA4">
                  <SHORT-NAME>PortInterfaces</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="799DF2FC-3233-444E-946A-73438C521F5F">
                  <SHORT-NAME>SwComponentTypes</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="9F5CC2C0-B8EF-4EE0-B90C-A81344DD5AB1">
          <SHORT-NAME>SystemComposition</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="1B7C081A-A352-4DB9-B515-8FC36DF55559">
          <SHORT-NAME>SystemDescription</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="1A41C5C8-0AE4-4E67-90ED-09C9F126E6AB">
              <SHORT-NAME>BaseTypes</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="8CE66BBE-3886-428D-9D54-463AF914B469">
              <SHORT-NAME>CompuMethods</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="5DAF73CA-3ED6-4B16-8F04-5823E199F51A">
              <SHORT-NAME>DataConstrs</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="DF664864-0EE4-40F2-8BAB-B0AE9876F1EC">
              <SHORT-NAME>Units</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="DCC3C6FA-1EA5-4CC6-BF5A-6F267EB52B43">
          <SHORT-NAME>Units</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="89F16C62-3759-4608-B6F4-7F1432C601B0">
              <SHORT-NAME>PhysicalDimensions</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="9DEA2BE0-355C-4E13-92D2-BFDE03DEAA60">
      <SHORT-NAME>ComponentType</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="19CEFAA9-10B3-4AD2-918B-4980E787B191">
          <SHORT-NAME>DataTypes</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="538C8C1B-84F4-4A0F-8A37-E51D8AE0C9F6">
              <SHORT-NAME>BaseTypes</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="69a0497a-eb74-4b75-aca4-88f509b3d466">
              <SHORT-NAME>CompuMethods</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="55873589-E0EE-403C-BE51-2DD3B5B55953">
      <SHORT-NAME>ComponentTypes</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="C6B49A8D-2381-44BA-B800-287FF63CED2E">
          <SHORT-NAME>ConstantMappingSets</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="724F61EC-1404-4369-BD78-CC7DF8F21376">
          <SHORT-NAME>DataTypeMappingSets</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="D696BFEA-50C5-45C2-B3CB-52579CDDB1D6">
      <SHORT-NAME>Constants</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="2930217E-9060-41F2-B841-A483C6F0BCC4">
      <SHORT-NAME>DataConstrs</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="F21B6134-18FE-427C-8794-24315541434A">
      <SHORT-NAME>DataDictionary</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="7D9FAD5E-EB8C-41B6-BE44-37B083ABF4FB">
          <SHORT-NAME>Calibrations</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="09FFFA2F-401A-4140-A773-2F20B351CA1D">
          <SHORT-NAME>ComponentTypes</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="DF50D58B-0264-4EF7-BAF5-36D1F552DFDA">
              <SHORT-NAME>DataTypeMappingSets</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="9A9A963E-E8C9-403C-ADCB-22EE25067A83">
          <SHORT-NAME>DataConstrs</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="6FC3C1F1-E6A4-4285-8C5E-5E919EA51B7C">
          <SHORT-NAME>DataTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="CFA3CD03-91CE-4069-AB4C-0686C5AD2DB4">
          <SHORT-NAME>Units</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="74B54A50-FD56-4CB4-8FF6-7BD98E73A9EB">
      <SHORT-NAME>DataType</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="BE4691EB-23EA-4851-9B03-6E0245623EB8">
          <SHORT-NAME>Semantics</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="421ACD5E-1FF5-4D5C-B892-9509909F49E3">
          <SHORT-NAME>Unit</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="B8CD42C6-E686-4D68-B4CE-9A006813279D">
      <SHORT-NAME>DataTypeMapping</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="81921ABE-717A-4504-A384-5E28E8CC33F0">
      <SHORT-NAME>DataTypes</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="1C9DB839-D710-4DDD-81EB-082B473FFE7B">
          <SHORT-NAME>BaseTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="44D2635A-1873-4CA1-9257-B468B14BAD99">
          <SHORT-NAME>CompuMethods</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="E4994FC5-3606-4713-B47E-E9B2AD0242D7">
          <SHORT-NAME>DataConstrs</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="EFBC2479-D585-4F8F-8CFB-F408DDE17CA0">
          <SHORT-NAME>PlatformTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="7FBB2E0A-B5B0-454F-8C64-C01A7C23CD8B">
          <SHORT-NAME>Units</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="52E4A299-91A5-4998-ACA6-62E8DB19710B">
      <SHORT-NAME>DaVinci</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="5CAE5749-2485-4B63-BAF4-DB564A84A548">
          <SHORT-NAME>PKG_ECU</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="AB15681F-F7E2-4301-86FA-9019F9759B2C">
      <SHORT-NAME>ECUCompositions</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="4A623C62-0F7A-41FE-98EF-3877C757A0DE">
      <SHORT-NAME>ECUCompositionTypes</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="EAA1D10F-D085-42BF-A063-7A18FDB43B6A">
      <SHORT-NAME>EndToEndProtections</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="663CE471-A0DB-42D0-8525-C6C3760A5656">
      <SHORT-NAME>Ford</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="71A30AEB-C61F-46F0-B5F3-7FD42D73088F">
          <SHORT-NAME>DataTypes</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="A35C05E5-3B02-417F-B58E-EE08FB69B9E2">
              <SHORT-NAME>DataConstrs</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="292001FB-DF49-4F2B-BD92-AFE425BE2AB1">
          <SHORT-NAME>PortInterfaces</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="ff55d029-386d-43a2-b3c2-dfef4c7a5e36">
      <SHORT-NAME>MICROSAR</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="9d2eebd0-6243-4515-86d5-484a79ce8e66">
          <SHORT-NAME>BswM_swc</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="5462e575-2b69-42cd-836b-102e260e1be7">
              <SHORT-NAME>ComponentTypes</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="1a4d2f4d-f2c7-4886-ab67-61df82b3f571">
          <SHORT-NAME>ComM_swc</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="66b9d596-18e7-4cdd-9779-fda316f3dcf9">
              <SHORT-NAME>ComponentTypes</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="36de012b-eae9-40be-b673-67e74a1a8f9b">
              <SHORT-NAME>DataTypes</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="87efe596-0e12-4f1b-9c1b-342ed21e4894">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="ff21eb17-f32c-4f4f-ab5a-ccf4aa051bb4">
                  <SHORT-NAME>DataConstrs</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="7a9f9107-60cc-4797-9203-91dd4a671fe7">
              <SHORT-NAME>Interfaces</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="a0d5b19a-cf25-4f92-b858-9adcc895773c">
          <SHORT-NAME>Dcm_swc</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="84f1cf3b-a6fe-4839-afee-80ed3a05c6c0">
              <SHORT-NAME>ComponentTypes</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="e9d234ee-b396-4620-8b4f-3e8deba2c4f7">
              <SHORT-NAME>DataTypes</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="7431277c-2491-49df-9231-e3d5b63e226a">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="e9cb486b-38e9-46f1-9414-5cbc7524e7f7">
                  <SHORT-NAME>DataConstrs</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="dac6ba71-8495-45de-bcc8-94d8412061fa">
              <SHORT-NAME>Interfaces</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="5e2fae6d-34c8-4884-a862-12dbf5960ac4">
          <SHORT-NAME>Dem_swc</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="5cba4e3e-f399-4d9d-9ac6-45c7ed5d90c3">
              <SHORT-NAME>ComponentTypes</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="8a275ef6-1e62-4f63-af16-158af56195f0">
              <SHORT-NAME>DataTypes</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="fb4717df-ef4c-4ae7-98bb-7643b618efcd">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="15c6d5f9-1ef3-4ec5-b5c1-391cb0a3ad9d">
                  <SHORT-NAME>DataConstrs</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="181e7e13-8294-4f18-836c-4a68ef1c4bb5">
              <SHORT-NAME>Interfaces</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="29999da7-9368-4cc4-a224-32300eeefb58">
          <SHORT-NAME>Det_swc</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="9af50cff-11b1-4225-b351-d4b0185a714b">
              <SHORT-NAME>ComponentTypes</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="9391db76-7e47-48d9-96d4-7a22ca38713b">
              <SHORT-NAME>Interfaces</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="70f5ad51-aa80-4ae6-81a4-0512623188e5">
          <SHORT-NAME>EcuM_swc</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="5c24b287-23b0-42ef-be52-8b80b6a4637d">
              <SHORT-NAME>ComponentTypes</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="09b343a4-d540-4bf7-9c52-c12419922823">
              <SHORT-NAME>DataTypes</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="fa2f944e-0192-4ccc-acb0-9f902d6f8ed0">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="7d089a53-e94e-4d50-8094-98260d415719">
                  <SHORT-NAME>DataConstrs</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="e2193845-05b0-4133-a3c0-a478cdcf8ae4">
              <SHORT-NAME>Interfaces</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="140feed9-e07e-44c5-ac5c-dfe4f2b88f5b">
          <SHORT-NAME>IoHwAb_swc</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="c9a8b525-e571-4fa0-8d7b-28e4571d5c08">
              <SHORT-NAME>ComponentTypes</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="7733d9ce-aad9-45d9-bd82-80615be3b6ae">
              <SHORT-NAME>DataTypes</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="6a52edd4-3c13-4293-bcd1-ae4080ab30b8">
              <SHORT-NAME>Interfaces</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="cbdb1f40-57fe-49a2-beaa-74ff959114e6">
          <SHORT-NAME>NvM_swc</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="bc38735d-8925-44d1-9b64-73c20131eedb">
              <SHORT-NAME>ComponentTypes</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="e2715c7e-bd18-4a64-a065-a1d4fef7e840">
              <SHORT-NAME>DataTypes</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="0893dc91-b96b-4e34-ac6c-08ad6871b706">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="ba7bcaf9-abbf-40ea-bf0d-2b9ff553b76d">
                  <SHORT-NAME>DataConstrs</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="65c9602b-9167-400d-9821-2107ea7233df">
              <SHORT-NAME>Interfaces</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="00057fbf-c4c3-4a6c-b0aa-857cb462142b">
          <SHORT-NAME>Os_swc</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="7aef23e8-a77b-4576-87d5-8429c480d6ad">
              <SHORT-NAME>ComponentTypes</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="1fb7d229-d1bf-44f7-bc4c-bf2641fdaf83">
              <SHORT-NAME>DataTypes</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="a663ced8-04a2-4019-8d26-a3efc8b4d796">
                  <SHORT-NAME>DataConstrs</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="13cf67a3-a1c2-4f70-a6b4-0300081f6a69">
              <SHORT-NAME>Interfaces</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="926da69c-6461-4a19-9f2d-36daae4302d5">
          <SHORT-NAME>WdgM_swc</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="3c33f1f8-fc61-4d7f-926c-a3dc7e76fb42">
              <SHORT-NAME>ComponentTypes</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="a9471b77-5311-44d8-90c0-7484961038f8">
              <SHORT-NAME>DataTypes</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="5d335507-cfca-402e-b888-11a5ef9ae482">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="bb4121b5-8d9d-446b-bc15-e222f03cb1d0">
                  <SHORT-NAME>DataConstrs</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="e10ef49a-b804-4b8c-a8e0-37a3800ced95">
              <SHORT-NAME>Interfaces</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="19D6DC96-1E93-4F46-B6A7-C4FB660183F1">
      <SHORT-NAME>MICROSAR_SWCS_DEV</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="D589A4FB-36CD-4679-A7C7-17A19602E91A">
          <SHORT-NAME>BswM_swc</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="F487B2BB-4944-4354-BAD2-0FACC56AD35E">
          <SHORT-NAME>Dem_swc</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="A7409673-E2A5-4759-99A9-F9579CCDC6FC">
              <SHORT-NAME>DataTypes</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="DB0E9E19-2796-464C-BA1C-9EA0BAEB25FD">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="257C27B8-C4A9-4E76-912E-613FDD681FC5">
                  <SHORT-NAME>DataConstrs</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="6546894C-9502-4E36-8ECF-19744F22A575">
          <SHORT-NAME>EcuM_swc</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="E305A152-8B30-4069-AB3F-9A21792157CE">
              <SHORT-NAME>DataTypes</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="BCDAADB5-230B-4379-93FE-EF9528EBF506">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="64255D4B-FD9D-44C6-818E-20025A6F258B">
                  <SHORT-NAME>DataConstrs</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="FF3F5C08-D74B-45FD-873D-874AC27D8CCB">
          <SHORT-NAME>NvM_swc</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="50FDA04A-6565-4F3A-94D7-23EA530E37E6">
              <SHORT-NAME>DataTypes</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="50C6B7A0-7C33-4528-A124-0625B554AFF7">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="104B0F8B-CB8D-473F-B6C0-CFEF4266CF64">
                  <SHORT-NAME>DataConstrs</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="B4E80F95-36BD-4183-A806-2B7D25181719">
          <SHORT-NAME>Os_swc</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="AB6A4C26-8996-4015-8E04-5C0C00B8DE7C">
              <SHORT-NAME>DataTypes</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="EAC3EBD5-9FE0-4FFD-8A52-E17BB3BF1B10">
                  <SHORT-NAME>DataConstrs</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="3B88D714-7662-432E-9419-7C0A77833E61">
          <SHORT-NAME>WdgM_swc</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="2FD2C83C-7F77-4511-BF2D-EDAB90DC7A3F">
              <SHORT-NAME>DataTypes</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="B4B043CF-9744-4A73-89FD-6F377F3C56F1">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="6BF0B3C5-BF87-4AC0-8E96-80B180E5B8D6">
                  <SHORT-NAME>DataConstrs</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="9EC97662-7F8F-4E3B-A38A-2B7B4475BF94">
      <SHORT-NAME>ModeDclrGroups</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="0C5BDAA1-0830-48F3-866A-4544228D6292">
      <SHORT-NAME>ModeDeclarationGroup</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="B4F5A09B-FAC2-44C2-A7A2-0E370C511F8D">
      <SHORT-NAME>Nxtr</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="40FA8A58-D827-43FB-9CAA-6566A343F97B">
          <SHORT-NAME>Calibrations</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="60B4DAEC-EA07-4AFC-853E-F1E19628954E">
          <SHORT-NAME>ComponentTypes</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="427CE6A1-ED67-4BB1-9018-568F9EC9C39C">
              <SHORT-NAME>DataTypeMappingSets</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="B6EED526-EB9C-43E7-948E-327109E2467B">
          <SHORT-NAME>DataConstrs</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="A96F0713-E97F-4677-BDA9-B2836A0CF99E">
          <SHORT-NAME>DataTypeMappingSets</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="D606F4CF-395C-4002-8DED-117B7AA2A2BC">
          <SHORT-NAME>DataTypes</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="172B6DD5-F18F-4595-BAB7-F2215C69DE97">
              <SHORT-NAME>BaseTypes</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="87F80A4F-6BCB-4AB3-B71C-E185AC924362">
              <SHORT-NAME>CompuMethods</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="172FE4F3-EA35-46A2-AF59-FBC3B0B8762D">
              <SHORT-NAME>DataConstrs</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="E93F6EFF-381F-456B-9B7F-EC0F9F7B7687">
          <SHORT-NAME>ModeDclrGroups</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="3127C774-147F-4405-A717-2DDF67A6659E">
          <SHORT-NAME>NvMProxy_swc</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="E95BF695-CA46-44DA-835A-05D94B642589">
              <SHORT-NAME>ComponentTypes</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="E6F1D64C-AE3C-41CC-9F2D-57BA63C7C318">
              <SHORT-NAME>DataTypes</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="B6E9B75E-F1E2-42CE-8D7C-F623CA410CAE">
                  <SHORT-NAME>BaseTypes</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="43A9C058-AD38-4EBE-82C6-24E2C3C34DA3">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="04B50E28-379E-4CAF-800E-742E155EAAB2">
                  <SHORT-NAME>DataConstrs</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="0B37E90B-DDF1-4003-A5EC-97F40355B5B6">
              <SHORT-NAME>Interfaces</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="2BB26679-94AF-490F-8CCF-25FE8795158B">
          <SHORT-NAME>PortInterfaces</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="F9105805-AE0F-4741-98DA-AC3309A91548">
          <SHORT-NAME>Units</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="A0AFF046-D9A6-4A7C-9EB1-4F9FB321AD15">
      <SHORT-NAME>PortInterface</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="7C93988E-0450-4FB4-A1EC-DABBE6247237">
      <SHORT-NAME>PortInterfaces</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="E0D54971-2DB3-4487-90AA-321AD3519108">
      <SHORT-NAME>Predefined_DEV</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="2C62B2E5-165D-4F78-98F7-EBE2136FE04E">
          <SHORT-NAME>CompuMethods</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="7282E893-24A4-429B-8022-0E2934AB9AF5">
          <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="4BA4ED3C-B337-4C37-9242-3349BDD73D8F">
          <SHORT-NAME>PortInterfaces</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="1C204E04-C1F1-4323-824D-EC34939081C4">
      <SHORT-NAME>Systems</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="DB8BC6F2-BA35-4918-A411-348DD68F247D">
          <SHORT-NAME>DiagnosticSwBaseTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="930AA4DB-E86A-4A34-8D2F-D9B40EB22048">
          <SHORT-NAME>EndToEndProtections</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="2F7AD553-CFED-4AD5-8987-00781C23543F">
          <SHORT-NAME>ModeDeclarationGroups</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="C41F6F8E-465A-48D6-B478-14A95E4E3CD6">
              <SHORT-NAME>BasePartialNetworks</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="F57ADAE3-D9CD-45DD-9922-87AECF7455DF">
              <SHORT-NAME>FunctionalPartialNetworks</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="ADC58AAF-5AA8-4FE0-851C-F87955AB21AF">
      <SHORT-NAME>Units</SHORT-NAME>
    </AR-PACKAGE>
  </AR-PACKAGES>
</AUTOSAR>