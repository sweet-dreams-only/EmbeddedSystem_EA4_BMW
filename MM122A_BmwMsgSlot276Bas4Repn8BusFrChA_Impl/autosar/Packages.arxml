<?xml version="1.0" encoding="utf-8"?>
<!--This file was saved with a tool from Vctr Informatik GmbH-->
<AUTOSAR xsi:schemaLocation="http://autosar.org/schema/r4.0 AUTOSAR_4-0-3.xsd" xmlns="http://autosar.org/schema/r4.0" xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance">
  <AR-PACKAGES>
    <AR-PACKAGE UUID="A87D20CC-A315-4FBE-869E-B1076C04C362">
      <SHORT-NAME>AUTOSAR_Platform</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="E1D127D5-6C32-4DA3-BF3E-D11DE01CE369">
          <SHORT-NAME>BaseTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="495D53E6-5750-46EC-B87C-46483DCF9A4E">
          <SHORT-NAME>CompuMethods</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="13A87195-A883-4F95-BA8A-0FBC71333A42">
          <SHORT-NAME>DataConstrs</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="1CC3CBBD-EDF2-4FCA-B693-3B33E4FEA220">
          <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="6B77E57D-2C9F-443A-ACAD-3AC681B04F41">
      <SHORT-NAME>Blueprints</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="5973249F-9076-474C-A3A4-C466F4376F37">
          <SHORT-NAME>BlueprintMappingSets</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="AFBBDEE0-0827-49D0-B354-F1E62CAADACF">
          <SHORT-NAME>PortPrototypeBlueprints</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="DECC039A-CEA2-45BA-971D-DFE08FB0BB28">
      <SHORT-NAME>BMW</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="7DE99D8F-E160-47A6-8961-D227D850F1C9">
          <SHORT-NAME>Boardnet</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="F3D853B9-E607-419B-807E-DB43EE493721">
              <SHORT-NAME>CodingDatatypes</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="36741A1A-E4F7-498C-AE58-FCED98748C7C">
                  <SHORT-NAME>CompuMethodsForBoardnet</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="F23B3146-C4AB-41FF-97BB-3AF2CBE1917C">
                  <SHORT-NAME>DataConstraints</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="88545082-85E6-4C98-8C4C-D09D795404A2">
                  <SHORT-NAME>SwBaseTypes</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="AE9CBECC-3685-4F15-AAB4-C3BECDA1EAD3">
          <SHORT-NAME>Platform</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="B42973F4-98D6-4F56-AE91-551FDA29559D">
              <SHORT-NAME>Auth</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="C416C6D8-DE48-4256-8D78-F698F1741E30">
                  <SHORT-NAME>Dcm</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="DCDFF09B-B4F3-41AC-A09F-EF4B1F033646">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="33EB6440-7B63-4EF2-B38D-EBB13D5BF474">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="06B74093-BDE4-4542-AC8C-1E580E25609A">
                  <SHORT-NAME>Dlog</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="344E4767-3888-4CAB-B1F4-CB12613F517E">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="4F184231-F0D9-4E4F-84ED-8573A4D5F9B9">
              <SHORT-NAME>Darh</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="491C55EA-7426-4308-817B-7C3D6C6412FD">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="205B68E6-8E91-412E-98C9-AB401C5A00E3">
                  <SHORT-NAME>Dcm</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="FE145571-D4DC-45F3-BB64-65EA5D7FE5A2">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="9C232C0A-9675-4A96-BB7A-1563958886C2">
                      <SHORT-NAME>DataConstrs</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="4175E00E-C587-473B-BFA3-448385134031">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="60E0E34F-297D-4A83-81A5-0C2E4503BE63">
                  <SHORT-NAME>Dem</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="520E0FAB-05F8-44CB-B695-F031D36E9938">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="50A7D18A-BFAF-4C28-94D2-B29AA3793C4B">
                      <SHORT-NAME>DataConstrs</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="7AF10E56-938B-4819-BD4C-5F5F6E0CEA16">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="87237BA1-9EDC-44EB-B83E-CA81FEFC49A4">
                  <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="6E7B5433-6F79-47AD-A877-2E9992E42EA5">
                  <SHORT-NAME>NvM</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="A3048AA2-A2EE-483E-99FB-3E2EEC399217">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="26E81313-5B3F-4EF9-B0C0-C1D722BF8CEC">
                      <SHORT-NAME>DataConstrs</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="0FD973F7-6FFD-4B34-B553-329B8E8D009C">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="228796A1-EAE6-461B-B92A-C1B7E85E9925">
              <SHORT-NAME>Dlog</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="E1C41B1C-8A6D-45A9-A5D1-0002CC3A0514">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="67749862-695A-45E7-AB20-812D082909A7">
                  <SHORT-NAME>Dcm</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="D5CA4651-EAF5-4752-B4DC-A3B0314A7BEB">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="6E4F0761-E0E8-4DC8-BA02-41992DE425D4">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="C70C63A6-2ABE-4124-9B3E-A32AB60E312D">
                  <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="98100E26-2F6E-4D59-9A1E-59C45C549155">
                  <SHORT-NAME>NvM</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="9117BED2-C714-43ED-B68F-0438F84A305E">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="F27112F0-D10F-49F7-B727-264FAE38222E">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="774F39A6-939C-4458-9212-6D1922DDF8C9">
              <SHORT-NAME>Omc</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="D25C5A3F-0D42-4208-BC8F-C7C07B57A34E">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="41BE3D9C-8F03-4F59-8722-22B72BF12614">
                  <SHORT-NAME>Dcm</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="DABC09BF-1B42-4856-998F-45EFA2DD5D71">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="EF791376-F3F6-429C-AF00-78BA85C1C84C">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="96D82CA5-F402-4157-850C-16F6CF5A28AC">
                  <SHORT-NAME>Dem</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="A7E4C218-3E3F-433E-BBB5-3BEAFD6D7D1F">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="A7158CA9-69A0-419C-A220-BB2B26B0A600">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="C6F0DFC3-B4C3-46AA-8257-6180C0BAA2BE">
                  <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="2C942CA7-822C-45F3-BB78-B32CFC7C507E">
                  <SHORT-NAME>NvM</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="ED496D94-2B60-48CC-9B1E-D9F22C6B4364">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="C93CCAD6-BD7A-4405-8211-8490A7DE6436">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="D4A1EB3A-F9E1-4417-9976-5FBA85D76C32">
              <SHORT-NAME>StdDiag</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="411C60CF-ADAF-4D8B-8398-01229C57D6EC">
                  <SHORT-NAME>Coding</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="8E4A5CCF-63C4-4BDF-AB62-35A4E3CFD04B">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="564C5989-D717-4A37-8140-4D827AB4CFC8">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="9733AB51-B133-47E2-AA3F-A8E1C5FE1CE9">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="C8A37D6B-13EA-431E-A4F7-43046BCB6A4C">
                  <SHORT-NAME>Dcm</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="F8175485-ADBA-4E38-AAA4-91FA093840CD">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="37150F1C-1318-4BBD-8FD4-264DAFC7A00B">
                      <SHORT-NAME>DataConstrs</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="A4D5199A-8A02-4B5A-8047-15C80D1385E8">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="0489642B-4E42-43E4-AEC0-94B110C54258">
                  <SHORT-NAME>Dem</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="19548679-6CD9-41BB-BA80-8128C5045F58">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="B1BF3039-A286-4BA7-BDBE-EB98227C4CAD">
                      <SHORT-NAME>DataConstrs</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="20509F2E-37CE-4DFC-981E-EDF46D40CFE4">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="A6801F8C-0B13-4BE1-B72D-C6F3D3104055">
                  <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="C9EFBC07-511E-4CB1-B257-5D7D747A16AC">
                  <SHORT-NAME>Omc</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="35F5105A-0F5F-483C-8DD2-2857368A249E">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="3E927227-CB9C-4669-985F-EF17E0BE1F57">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="41C71987-02A4-4E45-AA2B-E6683F86F9A9">
              <SHORT-NAME>Stm</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="378B3CC4-23D4-4B3F-82DE-F87CD84478DE">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="332C8CF1-F3AB-4B92-9AB5-E9EFEA2C0BB8">
                  <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="822A75CE-193A-4641-9355-90A5BC447765">
              <SHORT-NAME>SysTime</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="27CB2890-C235-48F2-AE78-5CE31A20E44B">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="86C9822D-2247-4186-9D5E-57D9134CE3AE">
                  <SHORT-NAME>Dcm</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="F42F347D-E873-4AD6-8F4A-9AA571A799AB">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="9F090187-CC2D-4606-AE32-CECE7C19C524">
                  <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="B3D38059-D072-443B-B8C8-E9DF3A5BCC2D">
              <SHORT-NAME>Vin</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="6DDA9A7E-5E02-448A-B27B-57D996DBBF29">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="10A76AD6-86C0-4DC9-9488-2BBE5FAEBC05">
                  <SHORT-NAME>Dem</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="818B888B-2C39-4037-BDA0-51A51A388E08">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="B4A6B8E7-020B-411B-B4FF-117BF022B1A3">
                      <SHORT-NAME>DataConstrs</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="BA47842D-7E88-4021-9713-CBD61E68C77C">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="66BD24FB-BCA8-4DAD-808E-35A0DAA23F42">
                  <SHORT-NAME>Dlog</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="137A9C5D-FB2B-4C4C-AD74-6F1256BCAB56">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="FA402606-2303-4950-9B29-46D9C551FA7A">
                  <SHORT-NAME>Fscsm</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="51F120EB-6657-45C6-B822-D2AB19154078">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="F55B924F-308B-4FD8-8029-4DBA303AD006">
                  <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="187D3428-6454-4273-B0DA-E7993BEFEEF0">
                  <SHORT-NAME>NvM</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="8A1E489D-B4B8-4089-B367-C5EDAE5ABCA9">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="3036CCAE-6129-4727-95E3-0CF45D15DC79">
                      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="6BDE6C14-3285-48FD-BD8D-5492A03A4893">
          <SHORT-NAME>SystemDescription</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="B8E3DA38-9ACB-41D0-AC99-3357841F60FB">
              <SHORT-NAME>BaseTypes</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="5F9C1B2F-0255-44F0-9804-543CF82C0DC9">
              <SHORT-NAME>CompuMethods</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="8CFE1406-45F0-4492-A611-E4A200117FA9">
              <SHORT-NAME>DataConstrs</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="8D27AB6E-59E4-443E-A1E9-5A53C6842C09">
              <SHORT-NAME>Units</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="55873589-E0EE-403C-BE51-2DD3B5B55953">
      <SHORT-NAME>ComponentTypes</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="C6B49A8D-2381-44BA-B800-287FF63CED2E">
          <SHORT-NAME>ConstantMappingSets</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="724F61EC-1404-4369-BD78-CC7DF8F21376">
          <SHORT-NAME>DataTypeMappingSets</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="D696BFEA-50C5-45C2-B3CB-52579CDDB1D6">
      <SHORT-NAME>Constants</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="BB1F7997-1FA2-4FC5-BD8D-B5491D83F78B">
      <SHORT-NAME>DataTypes</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="4A6B2F9B-7ED1-4444-BF19-950E6431C5DF">
          <SHORT-NAME>BaseTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="44D2635A-1873-4CA1-9257-B468B14BAD99">
          <SHORT-NAME>CompuMethods</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="B9F96FAA-57C4-448C-AF52-E80BF007AFDF">
          <SHORT-NAME>DataConstrs</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="FDA6E403-7277-46F5-B371-5091EC3FFAA6">
          <SHORT-NAME>PlatformTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="7FBB2E0A-B5B0-454F-8C64-C01A7C23CD8B">
          <SHORT-NAME>Units</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="AB15681F-F7E2-4301-86FA-9019F9759B2C">
      <SHORT-NAME>ECUCompositions</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="4A623C62-0F7A-41FE-98EF-3877C757A0DE">
      <SHORT-NAME>ECUCompositionTypes</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="EAA1D10F-D085-42BF-A063-7A18FDB43B6A">
      <SHORT-NAME>EndToEndProtections</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="8A3CAE3A-1528-4C34-B90D-AF044F3719EB">
      <SHORT-NAME>MICROSAR_SWCS_DEV</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="B43B9668-DBD5-4026-8B6A-9884C58A3897">
          <SHORT-NAME>BswM_swc</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="6F639DA6-0689-454A-A213-BD673F8D3A12">
          <SHORT-NAME>Dem_swc</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="77C11E7E-18D6-4923-A1DC-0A26EE2DF339">
              <SHORT-NAME>DataTypes</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="7D8EA124-364E-4971-8C90-A3E1FEAA1C7F">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="7DED7DE6-7327-4B48-8511-3096B9F5EE45">
                  <SHORT-NAME>DataConstrs</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="032F8421-F68B-4026-9A84-5FA86CA0143F">
          <SHORT-NAME>EcuM_swc</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="6985CBE5-6442-4568-BDD1-6FDE3EEC6E46">
              <SHORT-NAME>DataTypes</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="2888AB32-235A-40C9-A3EF-A1327BA237FC">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="0318C8E3-593C-47F4-B324-D835DAD81A4F">
                  <SHORT-NAME>DataConstrs</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="59977788-E048-43C6-B83D-54553669A3D2">
          <SHORT-NAME>NvM_swc</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="B3D076ED-D397-4878-9B52-5EB5EE09D958">
              <SHORT-NAME>DataTypes</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="4694DFA7-DB5B-4FBA-AB8E-3375E10164C7">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="BE99AD88-1134-4EA3-9ABA-FAB00479DB70">
                  <SHORT-NAME>DataConstrs</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="9A914182-615F-4EAA-8E98-EB22EAA559D0">
          <SHORT-NAME>Os_swc</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="930BCD5E-13F3-4FC8-B579-BC1A1170EED7">
              <SHORT-NAME>DataTypes</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="EA5C1949-5886-4B42-8D62-D84F3FB31C45">
                  <SHORT-NAME>DataConstrs</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="0512DC89-C4CB-4CF2-A2E9-12D339C8DC88">
          <SHORT-NAME>WdgM_swc</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="DBB0D8FE-A2E5-4178-AB82-4BC3EE94D8AD">
              <SHORT-NAME>DataTypes</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="602BF14C-791D-423B-9877-DD0B7CAAA362">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="D1E5E2E9-C287-4541-A5D9-C0E3C2BFDAEF">
                  <SHORT-NAME>DataConstrs</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="9EC97662-7F8F-4E3B-A38A-2B7B4475BF94">
      <SHORT-NAME>ModeDclrGroups</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="95874E61-2920-4EFD-ABA0-DF34C8C83AA8">
      <SHORT-NAME>Nxtr</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="40FA8A58-D827-43FB-9CAA-6566A343F97B">
          <SHORT-NAME>Calibrations</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="4C5767EE-5340-474C-AB52-636CA5C2588F">
          <SHORT-NAME>DataConstrs</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="3A9D6BEA-7C53-4A80-926D-11658C72F9B4">
          <SHORT-NAME>DataTypeMappingSets</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="1233AD22-0024-497F-8B44-E44065551062">
          <SHORT-NAME>DataTypes</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="172B6DD5-F18F-4595-BAB7-F2215C69DE97">
              <SHORT-NAME>BaseTypes</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="FE1F171A-27E1-4F1B-87CC-51760E0608FA">
              <SHORT-NAME>CompuMethods</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="E93F6EFF-381F-456B-9B7F-EC0F9F7B7687">
          <SHORT-NAME>ModeDclrGroups</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="C7B932D2-305B-4B24-B65B-BD2042586FAF">
          <SHORT-NAME>NvMProxy_swc</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="A5B82EF5-764F-448C-968F-DBAE9BD73387">
              <SHORT-NAME>DataTypes</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="0AF2DD3E-84FA-45CA-8E0E-CFACB8A2C6BB">
                  <SHORT-NAME>BaseTypes</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="9FE71ADF-811A-49C5-A36E-57FFAD9B7B9B">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="3F0C62DF-02E0-4674-BF57-67DD94D32F42">
                  <SHORT-NAME>DataConstrs</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="2BB26679-94AF-490F-8CCF-25FE8795158B">
          <SHORT-NAME>PortInterfaces</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="C6F08A27-5818-47A6-AF47-674E3D44AECC">
          <SHORT-NAME>Units</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="E2835249-D47F-4F13-AA17-4DAA902FE666">
      <SHORT-NAME>PortInterfaces</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="D802181B-82F2-4299-9731-48EDF6E2AFEE">
      <SHORT-NAME>Predefined_DEV</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="60E8D256-5EA7-483C-9655-3ED05324A940">
          <SHORT-NAME>CompuMethods</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="5DBDE02E-54A3-4A93-A0AC-C948AA68EC0F">
          <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="F8C69FB5-DEB4-4901-A4E9-0492ACE3281C">
      <SHORT-NAME>Systems</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="7B43E2C2-7F22-4948-AD6C-822F0670526C">
          <SHORT-NAME>ModeDeclarationGroups</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="418BB76F-8DDB-4F61-914B-E97E958C4239">
              <SHORT-NAME>BasePartialNetworks</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="804DA7C0-9E09-4001-8C79-9B5C0DC7AE10">
              <SHORT-NAME>FunctionalPartialNetworks</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
  </AR-PACKAGES>
</AUTOSAR>